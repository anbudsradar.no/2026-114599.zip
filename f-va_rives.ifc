Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [Default Description]
File name: C:\Users\vblu\AppData\Local\Temp\1\Trimble\ConnectFolder\f-va_rives.ifc
Time: 2026-08-28T10:40:29
Author: Vebjørn Bråthe Lund
Organization: Trimble Solutions Sandvika AS
Written by: Ifc Engine <1.0.1.1374>
Made in: Trimble Inc. - Novapoint - 28.0.699.0
Authorization: Vebjørn Bråthe Lund

# IfcProject, Default Project
Description: Description of the Project

# IfcSite, Default Site
Description: Description of Site; RefLatitude: 9, 36, 7; RefLongitude: 59, 11, 13; RefElevation: 25.1238 m

# IfcBuilding, Default Building
Description: Description of Building; ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m
Pset_BuildingCommon - IsPermanentID: no; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2; NumberOfStoreys: 0; IsLandmarked: no
Pset_BuildingWaterStorage - WaterStorageRatePerPerson: 0 m3; OneDayPotableWater: 0 m3; OneDayEssentialWater: 0 m3; OneDayCoolingTowerMakeupWater: 0 m3; OneDayProcessOrProductionWater: 0 m3
ePset_BuildingEnergyTarget - BuildingEnergyTargetValue: 0

# IfcBuildingStorey
In: Default Building
Description: Land Development storey; Elevation: 0 m

# IfcBuildingElementProxy: ProxyFeature (39)
Description: The IfcProxy is intended to be a kind of a container for wrapping objects which are defined by associated properties, which may or may not have a geometric representation and placement in space. A proxy may have a semantic meaning, defined by the Name attribute, and property definitions, attached through the property assignment relationship, which definition may be outside of the definitions given by the current release of IFC.
Name
_g-eks_va 1, Seksjon 93 - 48
_g-eks_va 1, Seksjon 33 - 34
_g-eks_va 1, Seksjon 78 - 92
_g-eks_va 1, Seksjon 97 - 71
_g-eks_va 1, Seksjon 95 - 46
_g-eks_va 1, Seksjon 45 - 46
_g-eks_va 1, Seksjon 5 - 6
17 x _g-eks_va 1, Bend
_g-eks_va 1, Seksjon 43 - 44
_g-eks_va 1, Seksjon 47 - 48
_g-eks_va 1, Seksjon 31 - 32
_g-eks_va 1, Seksjon 71 - 44
_g-eks_va 1, Seksjon 35 - 36
_g-eks_va 1, Seksjon 72 - 97
_g-eks_va 1, Seksjon 54 - 78
_g-eks_va 1, Seksjon 27 - 28
_g-eks_va 1, Seksjon 1 - 2
_g-eks_va 1, Seksjon 99 - 80
_g-eks_va 1, Seksjon 53 - 54
_g-eks_va 1, Seksjon 80 - 53
_g-eks_va 1, Seksjon 98 - 73
_g-eks_va 1, Seksjon 43 - 98
_g-eks_va 1, Seksjon 7 - 100

# IfcDistributionFlowElement (14)
Novapoint UtilityNetwork - ManholeMateriale: Betong; ManholeHasLadder: 0
A_Felles - A001 Prosjektnavn: Rv. 36 Moflata; A003 Prosjektfase: Byggeplan; A100 Fagkode: H_VA; A101 Revisjonsbokstav: A; A002 Prosjektnummer: C15211; A004 Område: Moflata; A102 Revisjonsdato: 2026.08.28; A103 Revisjonsmerknad: Arbeidsgrunnlag; A104 Produsert av: COWI; A105 Produsert for: Statens vegvesen; A106 Utført av: VBLU; A107 Kontrollert av: VUL; A005 Koordinatsystem: NTM sone 07 / NN2000; A108 Godkjent av: STHO
Name | Name | Navn = ManholeName | ManholeHeight | ManholeElevationAtTop | ManholeTaperDiameter | ManholeAdjustingUnitHeight | ManholeInnerBottomZ | ManholeSumpDepth | UtilityNetworkType | Diameter (DN) | Color | A205 Materialspesifikasjon = A206 Merknad
_g-eks_va 1, Eks SF7_UH_UP | _g-eks_va 1, Eks SF7_UH_UP | Eks SF7_UH_UP | 1.00627 | 29.5105 | 300 | 100 | 28.5042 | 0 | WS_StormwaterPipeNetwork | 650 | 0,0,0
_g-eks_va 1, Eks SF27 | _g-eks_va 1, Eks SF27 | Eks SF27 | 2.7553 | 28.8761 | 650 | 100 | 26.1208 | 1000 | WS_StormwaterPipeNetwork | 1000 | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2
_g-eks_va 1, Eks SF33 | _g-eks_va 1, Eks SF33 | Eks SF33 | 2.7553 | 30.0951 | 650 | 100 | 27.3398 | 1000 | WS_StormwaterPipeNetwork | 1000 | 0,0,0 | Kum rives når den blir gravd opp i Entreprise 2
_g-eks_va 1, Eks SF1_UH | _g-eks_va 1, Eks SF1_UH | Eks SF1_UH | 0.890657 | 29.5417 | 300 | 100 | 28.651 | 0 | WS_StormwaterPipeNetwork | 1000 | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2
_g-eks_va 1, Eks SF2_UH | _g-eks_va 1, Eks SF2_UH | Eks SF2_UH | 0.895257 | 29.0353 | 300 | 100 | 28.14 | 0 | WS_StormwaterPipeNetwork | 1000 | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2
_g-eks_va 1, Eks SF3_UH | _g-eks_va 1, Eks SF3_UH | Eks SF3_UH | 0.935691 | 28.9757 | 300 | 100 | 28.04 | 0 | WS_StormwaterPipeNetwork | 650 | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2
_g-eks_va 1, Eks SF35 | _g-eks_va 1, Eks SF35 | Eks SF35 | 1.25179 | 26.8088 | 650 | 100 | 25.557 | 371 | WS_StormwaterPipeNetwork | 1000 | 0,0,0 | Kum rives når den blir gravd opp i Entreprise 2
_g-eks_va 1, VK150313 | _g-eks_va 1, VK150313 | VK150313 | 2.20643 | 29.6764 | 650 | 200 | 27.47 | 0 | WS_WaterPipeNetwork | 1600 | 0,0,255 | Kum rives når den blir gravd opp i Entreprise 1 | A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, Eks VK130312 | _g-eks_va 1, Eks VK130312 | Eks VK130312 | 2.59011 | 29.2101 | 650 | 100 | 26.62 | 0 | WS_WaterPipeNetwork | 1600 | 0,0,255 | Kum rives når den blir gravd opp i Entreprise 1 | A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, OVK150306 | _g-eks_va 1, OVK150306 | OVK150306 | 2.63229 | 29.7623 | 650 | 200 | 27.13 | 0 | WS_StormwaterPipeNetwork | 1000 | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, SK150289 | _g-eks_va 1, SK150289 | SK150289 | 2.50231 | 29.8223 | 650 | 100 | 27.32 | 0 | WS_SewerNetwork | 1000 | 0,255,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, Eks OVK150305 | _g-eks_va 1, Eks OVK150305 | Eks OVK150305 | 1.78301 | 28.0348 | 650 | 100 | 26.2517 | 0 | WS_StormwaterPipeNetwork | 1000 | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, SK150288 | _g-eks_va 1, SK150288 | SK150288 | 1.81 | 28.37 | 650 | 100 | 26.56 | 0 | WS_SewerNetwork | 1000 | 0,255,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, VK139563 | _g-eks_va 1, VK139563 | VK139563 | 1.13343 | 30.8234 | 650 | 100 | 29.69 | 0 | WS_WaterPipeNetwork | 1000 | 0,0,255 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | A_Felles - A203 Objektstatus: Rives

# IfcFlowSegment (16)
Novapoint UtilityNetwork - Volume: 0 m3
A_Felles - A001 Prosjektnavn: Rv. 36 Moflata; A003 Prosjektfase: Byggeplan; A100 Fagkode: H_VA; A101 Revisjonsbokstav: A; A002 Prosjektnummer: C15211; A004 Område: Moflata; A102 Revisjonsdato: 2026.08.28; A103 Revisjonsmerknad: Arbeidsgrunnlag; A104 Produsert av: COWI; A105 Produsert for: Statens vegvesen; A106 Utført av: VBLU; A107 Kontrollert av: VUL; A005 Koordinatsystem: NTM sone 07 / NN2000; A108 Godkjent av: STHO
Name | Name | Navn = ManholeName | PipeClass | PipeMaterial | UtilityNetworkType | PipeType | PipeWallThickness | PipeHorizontalLength | PipeDeltaZ | PipeGradient | PipeNetworkUsage | Diameter (DN) | FromConnection | Length (m) | A203 Objektstatus | A205 Materialspesifikasjon = A206 Merknad | Color | Volume (m3) | Height (m) | ShortestHorizontalLength (m) | LongestHorizontalLength (m) | ProjectedAreaInTheHorizontalPlane (m2) | ToConnection
_g-eks_va 1, Eks SF16_Rives, Overvannsledning | _g-eks_va 1, Eks SF16_Rives, Overvannsledning | Overvannsledning | SN8 SDR 34 | Polyvinylklorid uten mykner Trykkløs | WS_StormwaterPipeNetwork | StormwaterPipe | 4.7 | 1.79549 | -0.017751 | -0.00988646 | Surface Water | 160 | _g-eks_va 1, Eks SF7_UH_UP | 1.79557 | Eksisterende | Utløp gjenbrukes av nye SF | 0,0,0 | 0.00411463 | 0.177723 | 0.159008 | 1.79565 | 0.287404
_g-eks_va 1, Eks SF1_Rives, Overvannsledning | _g-eks_va 1, Eks SF1_Rives, Overvannsledning | Overvannsledning | SN8 SDR 34 | Polyvinylklorid uten mykner Trykkløs | WS_StormwaterPipeNetwork | StormwaterPipe | 4.7 | 1.21588 | -0.017634 | -0.014503 | Surface Water | 160 | _g-eks_va 1, Eks SF1_UH | 1.21601 | Eksisterende | Utløp gjenbrukes av nye SF | 0,0,0 | 0.00278654 | 0.177597 | 0.158866 | 1.21618 | 0.194784
_g-eks_va 1, Eks SF2_Rives, Overvannsledning | _g-eks_va 1, Eks SF2_Rives, Overvannsledning | Overvannsledning | SN8 SDR 34 | Polyvinylklorid uten mykner Trykkløs | WS_StormwaterPipeNetwork | StormwaterPipe | 4.7 | 1.11509 | -0.016184 | -0.0145137 | Surface Water | 160 | _g-eks_va 1, Eks SF2_UH | 1.1152 | Eksisterende | Utløp gjenbrukes av nye SF | 0,0,0 | 0.00255554 | 0.176147 | 0.159513 | 1.11531 | 0.178661
_g-eks_va 1, Eks SF_Rives, Overvannsledning | _g-eks_va 1, Eks SF_Rives, Overvannsledning | Overvannsledning | SN8 SDR 34 | Polyvinylklorid uten mykner Trykkløs | WS_StormwaterPipeNetwork | StormwaterPipe | 4.7 | 1.23484 | -0.320677 | -0.259692 | Surface Water | 160 | _g-eks_va 1, Eks SF33 | 1.2758 | Eksisterende | Graves vekk dersom den avdekkes | 0,0,0 | 0.00292354 | 0.475521 | 0.166995 | 1.40705 | 0.202575
_g-eks_va 1, Eks SF 14_Rives, Overvannsledning | _g-eks_va 1, Eks SF 14_Rives, Overvannsledning | Overvannsledning | SN8 SDR 34 | Polyvinylklorid uten mykner Trykkløs | WS_StormwaterPipeNetwork | StormwaterPipe | 4.7 | 3.28797 | 0.296921 | 0.0903052 | Surface Water | 160 | _g-eks_va 1, Eks SF27 | 3.30135 | Eksisterende | Utløp gjenbrukes av nye SF | 0,0,0 | 0.00756518 | 0.456253 | 0.0011153 | 3.28889 | 0.52775
_g-eks_va 1, Eks SF3_Rives, Overvannsledning | _g-eks_va 1, Eks SF3_Rives, Overvannsledning | Overvannsledning | SN8 SDR 34 | Polyvinylklorid uten mykner Trykkløs | WS_StormwaterPipeNetwork | StormwaterPipe | 4.7 | 2.49942 | -0.113925 | -0.0455805 | Surface Water | 160 | _g-eks_va 1, Eks SF3_UH | 2.50202 | Eksisterende | Utløp gjenbrukes av nye SF | 0,0,0 | 0.00573348 | 0.273739 | 0.159712 | 2.50012 | 0.400722 | _g-eks_va 1, Ukjent_OVK_Kum 3
_g-eks_va 1, Eks SF14_Rives, Overvannsledning | _g-eks_va 1, Eks SF14_Rives, Overvannsledning | Overvannsledning | SN8 SDR 34 | Polyvinylklorid uten mykner Trykkløs | WS_StormwaterPipeNetwork | StormwaterPipe | 4.7 | 3.8645 | -0.803778 | -0.20799 | Surface Water | 160 | _g-eks_va 1, Eks SF35 | 3.9472 | Rives | Graves vekk dersom den avdekkes i Entreprise 2 | 0,0,0 | 0.00904517 | 0.960406 | 0.164391 | 3.86882 | 0.622255
_g-eks_va 1, VL_Saneres, Vannledning |  | Vannledning | C64 | Duktilt støpejern | WS_WaterPipeNetwork | WaterPipe | 4 | 14.6546 | -0.146149 | -0.00997291 |  | 150 | _g-eks_va 1, Eks VK130312 | 14.6553 | Rives | Ledning graves vekk når den avdekkes i Entreprise 1 | 0,0,255 | 0.0283423 | 0.304121 | 0.157662 | 14.6547 | 2.31504
_g-eks_va 1, SP-Kulvert_Saneres, Spillvannsledning |  | Spillvannsledning |  | Betong | WS_SewerNetwork | SewerPipe | 48 | 39.4275 | 0.76 | 0.0192759 |  | 250 | _g-eks_va 1, SK150288 | 39.4349 |  | Ledning graves vekk når den avdekkes i Entreprise 2 | 0,255,0 | 1.77091 | 1.10589 | 0.345398 | 39.428 | 13.6403 | _g-eks_va 1, SK150289 | Novapoint UtilityNetwork - PipeName: Spillvannsledning; Bruk: Waste Water
_g-eks_va 1, VL-Kulvert_Saneres, Vannledning |  | Vannledning | C64 | Duktilt støpejern | WS_WaterPipeNetwork | WaterPipe | 4 | 43.0997 | 0.87 | 0.0201858 |  | 150 | _g-eks_va 1, Eks VK130312 | 43.1084 | Rives | Ledning graves vekk når den avdekkes i Entreprise 1 | 0,0,255 | 0.0833684 | 1.02795 | 0.157673 | 43.0999 | 6.805 | _g-eks_va 1, VK150313
_g-eks_va 1, OV-Kulvert_Saneres, Overvannsledning | _g-eks_va 1, OV-Kulvert_Saneres, Overvannsledning | Overvannsledning |  | Betong | WS_StormwaterPipeNetwork | StormwaterPipe | 37 | 43.1943 | 0.72 | 0.0166689 | Surface Water | 200 | _g-eks_va 1, Eks OVK150305 | 43.2003 | Rives | Ledning graves vekk når den avdekkes i Entreprise 2 | 0,0,0 | 1.18931 | 0.993927 | 0.273753 | 43.1944 | 11.8332 | _g-eks_va 1, OVK150306
_g-eks_va 1, VL_Saneres2, Vannledning |  | Vannledning | C64 | Duktilt støpejern | WS_WaterPipeNetwork | WaterPipe | 4 | 38.5757 | -0.38518 | -0.00998504 |  | 150 |  | 38.5776 | Rives | Graves vekk dersom den avdekkes i Entreprise 2 | 0,0,255 | 0.0746061 | 0.543152 | 0.157662 | 31.9559 | 6.08815 | _g-eks_va 1, VK150313
_g-eks_va 1, Vannledning_Saneres(2), Vannledning |  | Vannledning | C50 | Duktilt støpejern | WS_WaterPipeNetwork | WaterPipe | 4.8 | 60.807 | -1.98348 | -0.0326193 |  | 250 | _g-eks_va 1, VK139563 | 60.8402 | Rives | Ledning graves vekk eller fylles med skumbetong i Entreprise 2 | 0,0,255 | 0.233609 | 2.24283 | 0.0012449 | 43.7535 | 15.7837 | _g-eks_va 1, VK10194
_g-eks_va 1, SP_Saneres, Spillvannsledning |  | Spillvannsledning |  | Betong | WS_SewerNetwork | SewerPipe | 48 | 31.7771 | -0.316943 | -0.00997393 |  | 250 |  | 31.7787 |  | Ledning graves vekk når den avdekkes i Entreprise 2 | 0,255,0 | 1.42709 | 0.662882 | 0.345266 | 31.7773 | 10.9931 | _g-eks_va 1, SK150289 | Novapoint UtilityNetwork - PipeName: Spillvannsledning; Bruk: Waste Water
_g-eks_va 1, OV_Saneres, Overvannsledning | _g-eks_va 1, OV_Saneres, Overvannsledning | Overvannsledning |  | Betong | WS_StormwaterPipeNetwork | StormwaterPipe | 37 | 29.1744 | -0.291652 | -0.00999684 | Surface Water | 200 |  | 29.1759 | Rives | Ledning graves vekk når den avdekkes i Entreprise 2 | 0,0,0 | 0.803216 | 0.565604 | 0.273691 | 29.1745 | 7.99237 | _g-eks_va 1, OVK150306
_g-eks_va 1, Vannledning_Saneres(2), Vannledning |  | Vannledning | C50 | Duktilt støpejern | WS_WaterPipeNetwork | WaterPipe | 4.8 | 31.6439 | 1.69316 | 0.0535065 |  | 250 |  | 31.6892 | Rives | Ledning graves vekk eller fylles med skumbetong i Entreprise 2 | 0,0,255 | 0.121677 | 1.95235 | 0.00136429 | 21.0555 | 8.21643 | _g-eks_va 1, VK139563

# IfcFlowTerminal (84)
A_Felles - A001 Prosjektnavn: Rv. 36 Moflata; A003 Prosjektfase: Byggeplan; A100 Fagkode: H_VA; A101 Revisjonsbokstav: A; A002 Prosjektnummer: C15211; A004 Område: Moflata; A102 Revisjonsdato: 2026.08.28; A103 Revisjonsmerknad: Arbeidsgrunnlag; A104 Produsert av: COWI; A105 Produsert for: Statens vegvesen; A106 Utført av: VBLU; A107 Kontrollert av: VUL; A005 Koordinatsystem: NTM sone 07 / NN2000; A108 Godkjent av: STHO
Name | Color | A205 Materialspesifikasjon = A206 Merknad | Novapoint ManholeProperties, ManholeName = Navn | ManholeMateriale | UtilityNetworkType | Novapoint UtilityNetwork, ManholeName | ManholeDiameter | ManholeMaterial | ManholeHeight | Novapoint UtilityNetwork, Volume (m3) = TRMB_QUADRI_Qto_BaseQuantities, Volume (m3) | Height (m) | LongestHorizontalLength (m) | ProjectedAreaInTheHorizontalPlane (m2)
_g-eks_va 1, Eks SF33, Bunnseksjon | 0,0,0 | Kum rives når den blir gravd opp i Entreprise 2 | Eks SF33 | Betong | WS_StormwaterPipeNetwork | Novapoint UtilityNetwork - ManholeInnerBottomZ: 27.3398; ManholeSumpDepth: 1000
_g-eks_va 1, Eks SF27, Kjegle | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF27 | Betong | WS_StormwaterPipeNetwork | Eks SF27 | 1000 | Betong | 2.7553 | 0.141879 | 0.5 | 3.74242 | 1.09285 | Novapoint UtilityNetwork - ManholeTaperHeight: 500; ManholeTaperDiameter: 650; Bruksomraade 1269: Eks SF; TRMB_QUADRI_Qto_BaseQuantities - ShortestHorizontalLength: 0.037439 m
_g-eks_va 1, Eks SF33, Kjegle | 0,0,0 | Kum rives når den blir gravd opp i Entreprise 2 | Eks SF33 | Betong | WS_StormwaterPipeNetwork | Eks SF33 | 1000 | Betong | 2.7553 | 0.141879 | 0.5 | 3.74233 | 1.09281 | Novapoint UtilityNetwork - ManholeTaperHeight: 500; ManholeTaperDiameter: 650; Bruksomraade 1269: Eks SF; TRMB_QUADRI_Qto_BaseQuantities - ShortestHorizontalLength: 0.037439 m
_g-eks_va 1, Eks SF27, Lokk |  | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF27 |  | WS_StormwaterPipeNetwork | Eks SF27 |  |  |  | 0.0149451 | 0.03 | 2.60597 | 0.540698 | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 650; ManholeCoverType: SJK Rist
_g-eks_va 1, Eks SF27, Bunnseksjon | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF27 | Betong | WS_StormwaterPipeNetwork | Novapoint UtilityNetwork - ManholeInnerBottomZ: 26.1208; ManholeSumpDepth: 1000
_g-eks_va 1, Eks SF33, Lokk |  | Kum rives når den blir gravd opp i Entreprise 2 | Eks SF33 |  | WS_StormwaterPipeNetwork | Eks SF33 |  |  |  | 0.0149451 | 0.03 | 2.60597 | 0.540698 | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 650; ManholeCoverType: SJK Rist
_g-eks_va 1, Eks SF27, Justeringsring | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF27 | Betong | WS_StormwaterPipeNetwork | Eks SF27 | 1000 | Betong | 2.7553 | 0.0192643 | 0.1 | 2.60597 | 0.20909 | Novapoint UtilityNetwork - ManholeTaperDiameter: 650; ManholeAdjustingDiameter: 650; ManholeAdjustingHeight: 100; ManholeAdjustingUnitHeight: 100
_g-eks_va 1, Eks SF33, Justeringsring | 0,0,0 | Kum rives når den blir gravd opp i Entreprise 2 | Eks SF33 | Betong | WS_StormwaterPipeNetwork | Eks SF33 | 1000 | Betong | 2.7553 | 0.0192643 | 0.1 | 2.60597 | 0.20909 | Novapoint UtilityNetwork - ManholeTaperDiameter: 650; ManholeAdjustingDiameter: 650; ManholeAdjustingHeight: 100; ManholeAdjustingUnitHeight: 100
_g-eks_va 1, Eks SF27, Bunnring | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF27 | Betong | WS_StormwaterPipeNetwork | Eks SF27 | 1000 | Betong | 2.7553 | 0.611585 | 2.1553 | 3.70499 | 0.307983 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 26.1208; ManholeSumpDepth: 1000
_g-eks_va 1, Eks SF33, Bunnring | 0,0,0 | Kum rives når den blir gravd opp i Entreprise 2 | Eks SF33 | Betong | WS_StormwaterPipeNetwork | Eks SF33 | 1000 | Betong | 2.7553 | 0.611585 | 2.1553 | 3.70499 | 0.307983 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 27.3398; ManholeSumpDepth: 1000
_g-eks_va 1, Eks SF27, Bunnplate | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF27 | Betong | WS_StormwaterPipeNetwork | Eks SF27 | 1000 | Betong | 2.7553 | 0.100689 | 0.1 | 3.70499 | 1.09285 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 26.1208; ManholeSumpDepth: 1000
_g-eks_va 1, Eks SF33, Bunnplate | 0,0,0 | Kum rives når den blir gravd opp i Entreprise 2 | Eks SF33 | Betong | WS_StormwaterPipeNetwork | Eks SF33 | 1000 | Betong | 2.7553 | 0.100689 | 0.1 | 3.70499 | 1.09285 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 27.3398; ManholeSumpDepth: 1000
_g-eks_va 1, Eks SF7_UH_UP, Lokk |  |  | Eks SF7_UH_UP |  | WS_StormwaterPipeNetwork | Eks SF7_UH_UP |  |  |  | 0.00419997 | 0.03 | 1.38144 | 0.151951 | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 300; ManholeCoverType: SJK Rist
_g-eks_va 1, Eks SF2_UH, Justeringsring | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF2_UH | Betong | WS_StormwaterPipeNetwork | Eks SF2_UH | 1000 | Betong | 0.895257 | 0.0101528 | 0.1 | 1.50702 | 0.110196 | Novapoint UtilityNetwork - ManholeTaperDiameter: 300; ManholeAdjustingDiameter: 300; ManholeAdjustingHeight: 100; ManholeAdjustingUnitHeight: 100
_g-eks_va 1, Eks SF1_UH, Justeringsring | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF1_UH | Betong | WS_StormwaterPipeNetwork | Eks SF1_UH | 1000 | Betong | 0.890657 | 0.0101528 | 0.1 | 1.50702 | 0.110196 | Novapoint UtilityNetwork - ManholeTaperDiameter: 300; ManholeAdjustingDiameter: 300; ManholeAdjustingHeight: 100; ManholeAdjustingUnitHeight: 100
_g-eks_va 1, Eks SF7_UH_UP, Justeringsring | 0,0,0 |  | Eks SF7_UH_UP | Betong | WS_StormwaterPipeNetwork | Eks SF7_UH_UP | 650 | Betong | 1.00627 | 0.00749169 | 0.1 | 1.38144 | 0.0813126 | Novapoint UtilityNetwork - ManholeTaperDiameter: 300; ManholeAdjustingDiameter: 300; ManholeAdjustingHeight: 100; ManholeAdjustingUnitHeight: 100
_g-eks_va 1, Eks SF2_UH, Bunnring | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF2_UH | Betong | WS_StormwaterPipeNetwork | Eks SF2_UH | 1000 | Betong | 0.895257 | 0.0837817 | 0.295257 | 3.70499 | 0.307983 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 28.14; ManholeSumpDepth: 0
_g-eks_va 1, Eks SF1_UH, Bunnring | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF1_UH | Betong | WS_StormwaterPipeNetwork | Eks SF1_UH | 1000 | Betong | 0.890657 | 0.19598 | 0.690657 | 3.70499 | 0.307983 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 28.651; ManholeSumpDepth: 0
_g-eks_va 1, Eks SF7_UH_UP, Bunnring | 0,0,0 |  | Eks SF7_UH_UP | Betong | WS_StormwaterPipeNetwork | Eks SF7_UH_UP | 650 | Betong | 1.00627 | 0.0592285 | 0.406275 | 2.48038 | 0.15823 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 28.5042; ManholeSumpDepth: 0
_g-eks_va 1, Eks SF2_UH, Lokk |  | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF2_UH |  | WS_StormwaterPipeNetwork | Eks SF2_UH |  |  |  | 0.00499832 | 0.03 | 1.50702 | 0.180834 | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 300; ManholeCoverType: SJK Rist
_g-eks_va 1, Eks SF1_UH, Lokk |  | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF1_UH |  | WS_StormwaterPipeNetwork | Eks SF1_UH |  |  |  | 0.00499832 | 0.03 | 1.50702 | 0.180834 | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 300; ManholeCoverType: SJK Rist
_g-eks_va 1, Eks SF2_UH, Bunnplate | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF2_UH | Betong | WS_StormwaterPipeNetwork | Eks SF2_UH | 1000 | Betong | 0.895257 | 0.100689 | 0.1 | 3.70499 | 1.09285 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 28.14; ManholeSumpDepth: 0
_g-eks_va 1, Eks SF1_UH, Bunnplate | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF1_UH | Betong | WS_StormwaterPipeNetwork | Eks SF1_UH | 1000 | Betong | 0.890657 | 0.100689 | 0.1 | 3.70499 | 1.09285 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 28.651; ManholeSumpDepth: 0
_g-eks_va 1, Eks SF7_UH_UP, Bunnplate | 0,0,0 |  | Eks SF7_UH_UP | Betong | WS_StormwaterPipeNetwork | Eks SF7_UH_UP | 650 | Betong | 1.00627 | 0.0451309 | 0.1 | 2.48038 | 0.489838 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 28.5042; ManholeSumpDepth: 0
_g-eks_va 1, Eks SF2_UH, Bunnseksjon | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF2_UH | Betong | WS_StormwaterPipeNetwork | Novapoint UtilityNetwork - ManholeInnerBottomZ: 28.14; ManholeSumpDepth: 0
_g-eks_va 1, Eks SF1_UH, Bunnseksjon | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF1_UH | Betong | WS_StormwaterPipeNetwork | Novapoint UtilityNetwork - ManholeInnerBottomZ: 28.651; ManholeSumpDepth: 0
_g-eks_va 1, Eks SF7_UH_UP, Bunnseksjon | 0,0,0 |  | Eks SF7_UH_UP | Betong | WS_StormwaterPipeNetwork | Novapoint UtilityNetwork - ManholeInnerBottomZ: 28.5042; ManholeSumpDepth: 0
_g-eks_va 1, Eks SF2_UH, Kjegle | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF2_UH | Betong | WS_StormwaterPipeNetwork | Eks SF2_UH | 1000 | Betong | 0.895257 | 0.141879 | 0.5 | 3.70499 | 0.962982 | Novapoint UtilityNetwork - ManholeTaperHeight: 500; ManholeTaperDiameter: 300; Bruksomraade 1269: Eks SF
_g-eks_va 1, Eks SF1_UH, Kjegle | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF1_UH | Betong | WS_StormwaterPipeNetwork | Eks SF1_UH | 1000 | Betong | 0.890657 | 0.0283759 | 0.1 | 3.70499 | 0.962982 | Novapoint UtilityNetwork - ManholeTaperHeight: 100; ManholeTaperDiameter: 300; Bruksomraade 1269: Eks SF
_g-eks_va 1, Eks SF7_UH_UP, Kjegle | 0,0,0 |  | Eks SF7_UH_UP | Betong | WS_StormwaterPipeNetwork | Eks SF7_UH_UP | 650 | Betong | 1.00627 | 0.0728921 | 0.5 | 2.48041 | 0.489799 | Novapoint UtilityNetwork - ManholeTaperHeight: 500; ManholeTaperDiameter: 300; Bruksomraade 1269: Eks SF
_g-eks_va 1, Eks SF3_UH, Lokk |  | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF3_UH |  | WS_StormwaterPipeNetwork | Eks SF3_UH |  |  |  | 0.00419997 | 0.03 | 1.38144 | 0.151951 | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 300; ManholeCoverType: SJK Rist
_g-eks_va 1, Eks SF3_UH, Bunnring | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF3_UH | Betong | WS_StormwaterPipeNetwork | Eks SF3_UH | 650 | Betong | 0.935691 | 0.107252 | 0.735691 | 2.48038 | 0.15823 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 28.04; ManholeSumpDepth: 0
_g-eks_va 1, Eks SF3_UH, Justeringsring | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF3_UH | Betong | WS_StormwaterPipeNetwork | Eks SF3_UH | 650 | Betong | 0.935691 | 0.00749169 | 0.1 | 1.38144 | 0.0813126 | Novapoint UtilityNetwork - ManholeTaperDiameter: 300; ManholeAdjustingDiameter: 300; ManholeAdjustingHeight: 100; ManholeAdjustingUnitHeight: 100
_g-eks_va 1, Eks SF3_UH, Bunnplate | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF3_UH | Betong | WS_StormwaterPipeNetwork | Eks SF3_UH | 650 | Betong | 0.935691 | 0.0451309 | 0.1 | 2.48038 | 0.489838 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 28.04; ManholeSumpDepth: 0
_g-eks_va 1, Eks SF3_UH, Bunnseksjon | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF3_UH | Betong | WS_StormwaterPipeNetwork | Novapoint UtilityNetwork - ManholeInnerBottomZ: 28.04; ManholeSumpDepth: 0
_g-eks_va 1, Eks SF3_UH, Kjegle | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks SF3_UH | Betong | WS_StormwaterPipeNetwork | Eks SF3_UH | 650 | Betong | 0.935691 | 0.0145784 | 0.1 | 2.48041 | 0.489799 | Novapoint UtilityNetwork - ManholeTaperHeight: 100; ManholeTaperDiameter: 300; Bruksomraade 1269: Eks SF
_g-eks_va 1, Eks SF35, Lokk |  | Kum rives når den blir gravd opp i Entreprise 2 | Eks SF35 |  | WS_StormwaterPipeNetwork | Eks SF35 |  |  |  | 0.0149451 | 0.03 | 2.60597 | 0.540698 | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 650; ManholeCoverType: SJK Rist
_g-eks_va 1, Eks SF35, Justeringsring | 0,0,0 | Kum rives når den blir gravd opp i Entreprise 2 | Eks SF35 | Betong | WS_StormwaterPipeNetwork | Eks SF35 | 1000 | Betong | 1.25179 | 0.0192643 | 0.1 | 2.60597 | 0.20909 | Novapoint UtilityNetwork - ManholeTaperDiameter: 650; ManholeAdjustingDiameter: 650; ManholeAdjustingHeight: 100; ManholeAdjustingUnitHeight: 100
_g-eks_va 1, Eks SF35, Bunnring | 0,0,0 | Kum rives når den blir gravd opp i Entreprise 2 | Eks SF35 | Betong | WS_StormwaterPipeNetwork | Eks SF35 | 1000 | Betong | 1.25179 | 0.184952 | 0.651794 | 3.70499 | 0.307983 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 25.557; ManholeSumpDepth: 371
_g-eks_va 1, Eks SF35, Bunnplate | 0,0,0 | Kum rives når den blir gravd opp i Entreprise 2 | Eks SF35 | Betong | WS_StormwaterPipeNetwork | Eks SF35 | 1000 | Betong | 1.25179 | 0.100689 | 0.1 | 3.70499 | 1.09285 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 25.557; ManholeSumpDepth: 371
_g-eks_va 1, Eks SF35, Bunnseksjon | 0,0,0 | Kum rives når den blir gravd opp i Entreprise 2 | Eks SF35 | Betong | WS_StormwaterPipeNetwork | Novapoint UtilityNetwork - ManholeInnerBottomZ: 25.557; ManholeSumpDepth: 371
_g-eks_va 1, Eks SF35, Kjegle | 0,0,0 | Kum rives når den blir gravd opp i Entreprise 2 | Eks SF35 | Betong | WS_StormwaterPipeNetwork | Eks SF35 | 1000 | Betong | 1.25179 | 0.141879 | 0.5 | 3.70501 | 1.09286 | Novapoint UtilityNetwork - ManholeTaperHeight: 500; ManholeTaperDiameter: 650; Bruksomraade 1269: Eks SF
_g-eks_va 1, VK150313, Bunnseksjon | 0,0,255 | Kum rives når den blir gravd opp i Entreprise 1 | VK150313 | Betong | WS_WaterPipeNetwork | Novapoint UtilityNetwork - ManholeInnerBottomZ: 27.47; ManholeSumpDepth: 0; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, Eks VK130312, Bunnseksjon | 0,0,255 | Kum rives når den blir gravd opp i Entreprise 1 | Eks VK130312 | Betong | WS_WaterPipeNetwork | Novapoint UtilityNetwork - ManholeInnerBottomZ: 26.62; ManholeSumpDepth: 0; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, Eks VK130312, Bunnplate | 0,0,255 | Kum rives når den blir gravd opp i Entreprise 1 | Eks VK130312 | Betong | WS_WaterPipeNetwork | Eks VK130312 | 1600 | Betong | 2.59011 | 0.229118 | 0.1 | 5.58928 | 2.48679 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 26.62; ManholeSumpDepth: 0; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, Eks VK130312, Bunnring | 0,0,255 | Kum rives når den blir gravd opp i Entreprise 1 | Eks VK130312 | Betong | WS_WaterPipeNetwork | Eks VK130312 | 1600 | Betong | 2.59011 | 0.875559 | 1.99011 | 5.58922 | 0.477516 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 26.62; ManholeSumpDepth: 0; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, Eks VK130312, Kjegle | 0,0,255 | Kum rives når den blir gravd opp i Entreprise 1 | Eks VK130312 | Betong | WS_WaterPipeNetwork | Eks VK130312 | 1600 | Betong | 2.59011 | 0.219978 | 0.5 | 5.58922 | 2.04991 | Novapoint UtilityNetwork - ManholeTaperHeight: 500; ManholeTaperDiameter: 650; Bruksomraade 1269: VK; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, Eks VK130312, Justeringsring | 0,0,255 | Kum rives når den blir gravd opp i Entreprise 1 | Eks VK130312 | Betong | WS_WaterPipeNetwork | Eks VK130312 | 1600 | Betong | 2.59011 | 0.0192643 | 0.1 | 2.60597 | 0.20909 | Novapoint UtilityNetwork - ManholeTaperDiameter: 650; ManholeAdjustingDiameter: 650; ManholeAdjustingHeight: 100; ManholeAdjustingUnitHeight: 100; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, Eks VK130312, Lokk |  | Kum rives når den blir gravd opp i Entreprise 1 | Eks VK130312 |  | WS_WaterPipeNetwork | Eks VK130312 |  |  |  | 0.0249084 | 0.05 | 2.60597 | 0.540698 | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 650; ManholeCoverType: SJK; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, VK150313, Bunnplate | 0,0,255 | Kum rives når den blir gravd opp i Entreprise 1 | VK150313 | Betong | WS_WaterPipeNetwork | VK150313 | 1600 | Betong | 2.20643 | 0.229118 | 0.1 | 5.58928 | 2.48679 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 27.47; ManholeSumpDepth: 0; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, VK150313, Bunnring | 0,0,255 | Kum rives når den blir gravd opp i Entreprise 1 | VK150313 | Betong | WS_WaterPipeNetwork | VK150313 | 1600 | Betong | 2.20643 | 0.662761 | 1.50643 | 5.58922 | 0.477516 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 27.47; ManholeSumpDepth: 0; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, OVK150306, Bunnplate | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | OVK150306 | Betong | WS_StormwaterPipeNetwork | OVK150306 | 1000 | Betong | 2.63229 | 0.100689 | 0.1 | 3.70499 | 1.09285 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 27.13; ManholeSumpDepth: 0; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, OVK150306, Bunnseksjon | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | OVK150306 | Betong | WS_StormwaterPipeNetwork | Novapoint UtilityNetwork - ManholeInnerBottomZ: 27.13; ManholeSumpDepth: 0; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, OVK150306, Bunnring | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | OVK150306 | Betong | WS_StormwaterPipeNetwork | OVK150306 | 1000 | Betong | 2.63229 | 0.548305 | 1.93229 | 3.70499 | 0.307983 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 27.13; ManholeSumpDepth: 0; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, OVK150306, Kjegle | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | OVK150306 | Betong | WS_StormwaterPipeNetwork | OVK150306 | 1000 | Betong | 2.63229 | 0.141879 | 0.5 | 3.70499 | 0.704534 | Novapoint UtilityNetwork - ManholeTaperHeight: 500; ManholeTaperDiameter: 650; Bruksomraade 1269: Eks OVK; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, OVK150306, Justeringsring | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | OVK150306 | Betong | WS_StormwaterPipeNetwork | OVK150306 | 1000 | Betong | 2.63229 | 0.0385287 | 0.2 | 2.60597 | 0.20909 | Novapoint UtilityNetwork - ManholeTaperDiameter: 650; ManholeAdjustingDiameter: 650; ManholeAdjustingHeight: 200; ManholeAdjustingUnitHeight: 200; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, OVK150306, Lokk |  | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | OVK150306 |  | WS_StormwaterPipeNetwork | OVK150306 |  |  |  | 0.0149451 | 0.03 | 2.60597 | 0.540698 | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 650; ManholeCoverType: SJK; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, SK150289, Bunnseksjon | 0,255,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | SK150289 | Betong | WS_SewerNetwork | Novapoint UtilityNetwork - ManholeInnerBottomZ: 27.32; ManholeSumpDepth: 0; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, SK150289, Bunnring | 0,255,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | SK150289 | Betong | WS_SewerNetwork | SK150289 | 1000 | Betong | 2.50231 | 0.539797 | 1.90231 | 3.70499 | 0.307983 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 27.32; ManholeSumpDepth: 0; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, SK150289, Bunnplate | 0,255,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | SK150289 | Betong | WS_SewerNetwork | SK150289 | 1000 | Betong | 2.50231 | 0.100689 | 0.1 | 3.70499 | 1.09285 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 27.32; ManholeSumpDepth: 0; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, SK150289, Kjegle | 0,255,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | SK150289 | Betong | WS_SewerNetwork | SK150289 | 1000 | Betong | 2.50231 | 0.141879 | 0.5 | 3.70499 | 0.704534 | Novapoint UtilityNetwork - ManholeTaperHeight: 500; ManholeTaperDiameter: 650; Bruksomraade 1269: SK; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, SK150289, Justeringsring | 0,255,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | SK150289 | Betong | WS_SewerNetwork | SK150289 | 1000 | Betong | 2.50231 | 0.0192643 | 0.1 | 2.60597 | 0.20909 | Novapoint UtilityNetwork - ManholeTaperDiameter: 650; ManholeAdjustingDiameter: 650; ManholeAdjustingHeight: 100; ManholeAdjustingUnitHeight: 100; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, Eks OVK150305, Bunnseksjon | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks OVK150305 | Betong | WS_StormwaterPipeNetwork | Novapoint UtilityNetwork - ManholeInnerBottomZ: 26.2517; ManholeSumpDepth: 0; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, Eks OVK150305, Bunnplate | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks OVK150305 | Betong | WS_StormwaterPipeNetwork | Eks OVK150305 | 1000 | Betong | 1.78301 | 0.100689 | 0.1 | 3.70499 | 1.09285 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 26.2517; ManholeSumpDepth: 0; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, Eks OVK150305, Bunnring | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks OVK150305 | Betong | WS_StormwaterPipeNetwork | Eks OVK150305 | 1000 | Betong | 1.78301 | 0.33569 | 1.18301 | 3.70499 | 0.307983 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 26.2517; ManholeSumpDepth: 0; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, Eks OVK150305, Justeringsring | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks OVK150305 | Betong | WS_StormwaterPipeNetwork | Eks OVK150305 | 1000 | Betong | 1.78301 | 0.0192643 | 0.1 | 2.60597 | 0.20909 | Novapoint UtilityNetwork - ManholeTaperDiameter: 650; ManholeAdjustingDiameter: 650; ManholeAdjustingHeight: 100; ManholeAdjustingUnitHeight: 100; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, Eks OVK150305, Kjegle | 0,0,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks OVK150305 | Betong | WS_StormwaterPipeNetwork | Eks OVK150305 | 1000 | Betong | 1.78301 | 0.141879 | 0.5 | 3.70499 | 0.704534 | Novapoint UtilityNetwork - ManholeTaperHeight: 500; ManholeTaperDiameter: 650; Bruksomraade 1269: Eks OVK; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, Eks OVK150305, Lokk |  | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | Eks OVK150305 |  | WS_StormwaterPipeNetwork | Eks OVK150305 |  |  |  | 0.0249084 | 0.05 | 2.60597 | 0.540698 | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 650; ManholeCoverType: SJK; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, SK150288, Bunnseksjon | 0,255,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | SK150288 | Betong | WS_SewerNetwork | Novapoint UtilityNetwork - ManholeInnerBottomZ: 26.56; ManholeSumpDepth: 0; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, SK150288, Bunnplate | 0,255,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | SK150288 | Betong | WS_SewerNetwork | SK150288 | 1000 | Betong | 1.81 | 0.100689 | 0.1 | 3.70499 | 1.09285 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 26.56; ManholeSumpDepth: 0; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, SK150288, Bunnring | 0,255,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | SK150288 | Betong | WS_SewerNetwork | SK150288 | 1000 | Betong | 1.81 | 0.343349 | 1.21 | 3.70499 | 0.307983 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 26.56; ManholeSumpDepth: 0; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, SK150288, Kjegle | 0,255,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | SK150288 | Betong | WS_SewerNetwork | SK150288 | 1000 | Betong | 1.81 | 0.141879 | 0.5 | 3.70499 | 0.704534 | Novapoint UtilityNetwork - ManholeTaperHeight: 500; ManholeTaperDiameter: 650; Bruksomraade 1269: SK; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, SK150288, Justeringsring | 0,255,0 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | SK150288 | Betong | WS_SewerNetwork | SK150288 | 1000 | Betong | 1.81 | 0.0192643 | 0.1 | 2.60597 | 0.20909 | Novapoint UtilityNetwork - ManholeTaperDiameter: 650; ManholeAdjustingDiameter: 650; ManholeAdjustingHeight: 100; ManholeAdjustingUnitHeight: 100; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, VK139563, Bunnseksjon | 0,0,255 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | VK139563 | Betong | WS_WaterPipeNetwork | Novapoint UtilityNetwork - ManholeInnerBottomZ: 29.69; ManholeSumpDepth: 0; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, VK139563, Bunnplate | 0,0,255 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | VK139563 | Betong | WS_WaterPipeNetwork | VK139563 | 1000 | Betong | 1.13343 | 0.100689 | 0.1 | 3.70499 | 1.09285 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 29.69; ManholeSumpDepth: 0; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, VK139563, Kjegle | 0,0,255 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | VK139563 | Betong | WS_WaterPipeNetwork | VK139563 | 1000 | Betong | 1.13343 | 0.141879 | 0.5 | 3.70499 | 0.704534 | Novapoint UtilityNetwork - ManholeTaperHeight: 500; ManholeTaperDiameter: 650; Bruksomraade 1269: VK; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, VK139563, Bunnring | 0,0,255 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | VK139563 | Betong | WS_WaterPipeNetwork | VK139563 | 1000 | Betong | 1.13343 | 0.151366 | 0.533432 | 3.70499 | 0.307983 | Novapoint UtilityNetwork - ManholeInnerBottomZ: 29.69; ManholeSumpDepth: 0; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, VK139563, Justeringsring | 0,0,255 | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | VK139563 | Betong | WS_WaterPipeNetwork | VK139563 | 1000 | Betong | 1.13343 | 0.0192643 | 0.1 | 2.60597 | 0.20909 | Novapoint UtilityNetwork - ManholeTaperDiameter: 650; ManholeAdjustingDiameter: 650; ManholeAdjustingHeight: 100; ManholeAdjustingUnitHeight: 100; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, VK150313, Kjegle | 0,0,255 | Kum rives når den blir gravd opp i Entreprise 1 | VK150313 | Betong | WS_WaterPipeNetwork | VK150313 | 1600 | Betong | 2.20643 | 0.219978 | 0.5 | 5.58922 | 2.04991 | Novapoint UtilityNetwork - ManholeTaperHeight: 500; ManholeTaperDiameter: 650; Bruksomraade 1269: VK; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, VK150313, Lokk |  | Kum rives når den blir gravd opp i Entreprise 1 | VK150313 |  | WS_WaterPipeNetwork | VK150313 |  |  |  | 0.0149451 | 0.03 | 2.60597 | 0.540698 | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 650; ManholeCoverType: SJK; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, SK150289, Lokk |  | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | SK150289 |  | WS_SewerNetwork | SK150289 |  |  |  | 0.0149451 | 0.03 | 2.60597 | 0.540698 | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 650; ManholeCoverType: SJK; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, VK150313, Justeringsring | 0,0,255 | Kum rives når den blir gravd opp i Entreprise 1 | VK150313 | Betong | WS_WaterPipeNetwork | VK150313 | 1600 | Betong | 2.20643 | 0.0385287 | 0.2 | 2.60597 | 0.20909 | Novapoint UtilityNetwork - ManholeTaperDiameter: 650; ManholeAdjustingDiameter: 650; ManholeAdjustingHeight: 200; ManholeAdjustingUnitHeight: 200; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, SK150288, Lokk |  | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | SK150288 |  | WS_SewerNetwork | SK150288 |  |  |  | 0.0149451 | 0.03 | 2.60597 | 0.540698 | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 650; ManholeCoverType: SJK; A_Felles - A203 Objektstatus: Rives
_g-eks_va 1, VK139563, Lokk |  | Kum rives/gjenfylles når den blir gravd opp i Entreprise 2 | VK139563 |  | WS_WaterPipeNetwork | VK139563 |  |  |  | 0.0149451 | 0.03 | 2.60597 | 0.540698 | Novapoint UtilityNetwork - ManholeAdjustingDiameter: 650; ManholeCoverType: SJK
