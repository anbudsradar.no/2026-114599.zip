Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [Default Description]
File name: \\COWI.net\projects\A280000\A280778\3.7_Tegninger\Plandata\3d\mod_grunnlag\Arb.mappe elektro\Trimble\Entreprise1\f_el_entreprise1.ifc
Time: 2026-08-31T19:03:07
Author: Vebjørn Bråthe Lund
Organization: Trimble Solutions Sandvika AS
Written by: Ifc Engine <1.0.1.1374>
Made in: Trimble Inc. - Novapoint - 28.0.699.0
Authorization: Vebjørn Bråthe Lund

# IfcProject, Default Project
Description: Description of the Project

# IfcSite, Default Site
Description: Description of Site; RefLatitude: 9, 36, 4; RefLongitude: 59, 11, 15; RefElevation: 26.8915 m

# IfcBuilding, Default Building
Description: Description of Building; ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m
Pset_BuildingCommon - IsPermanentID: no; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2; NumberOfStoreys: 0; IsLandmarked: no
Pset_BuildingWaterStorage - WaterStorageRatePerPerson: 0 m3; OneDayPotableWater: 0 m3; OneDayEssentialWater: 0 m3; OneDayCoolingTowerMakeupWater: 0 m3; OneDayProcessOrProductionWater: 0 m3
ePset_BuildingEnergyTarget - BuildingEnergyTargetValue: 0

# IfcBuildingStorey
In: Default Building
Description: Land Development storey; Elevation: 0 m

# IfcBuildingElementProxy: ProxyFeature (390)
Description: The IfcProxy is intended to be a kind of a container for wrapping objects which are defined by associated properties, which may or may not have a geometric representation and placement in space. A proxy may have a semantic meaning, defined by the Name attribute, and property definitions, attached through the property assignment relationship, which definition may be outside of the definitions given by the current release of IFC.
Name
Føringsveier_elektro, Seksjon 203 - 204
316 x Føringsveier_elektro, Bend
Føringsveier_elektro, Seksjon 264 - 265
Føringsveier_elektro, Seksjon 324 - 325
Føringsveier_elektro, Seksjon 232 - 251
Føringsveier_elektro, Seksjon 252 - 253
Føringsveier_elektro, Seksjon 251 - 252
Føringsveier_elektro, Seksjon 308 - 309
Føringsveier_elektro, Seksjon 309 - 310
Føringsveier_elektro, Seksjon 311 - 312
Føringsveier_elektro, Seksjon 310 - 311
Føringsveier_elektro, Seksjon 240 - 241
Føringsveier_elektro, Seksjon 241 - 242
Føringsveier_elektro, Seksjon 239 - 240
Føringsveier_elektro, Seksjon 242 - 243
Føringsveier_elektro, Seksjon 243 - 244
Føringsveier_elektro, Seksjon 244 - 245
Føringsveier_elektro, Seksjon 275 - 276
Føringsveier_elektro, Seksjon 274 - 275
Føringsveier_elektro, Seksjon 273 - 274
Føringsveier_elektro, Seksjon 272 - 273
Føringsveier_elektro, Seksjon 276 - 277
Føringsveier_elektro, Seksjon 266 - 267
Føringsveier_elektro, Seksjon 267 - 268
2 x 763501_fordelingsskap_EKS | A_Felles - A203 Objektstatus: Midlertidig; A202 MMI: 400; A200 Objektkode: 76356000; A201 Objektnavn: andre-kiosker-og-skap; A108 Godkjent av: OHTR; A0107 Kontrollert av: JHDA; A106 Utført av: NHMO; A105 Produsert for: Statens Vegvesen; A104 Produsert av: COWI; A103 Revisjonsmerknad: Arbeidsgrunnlag; A102 Revisjonsdato: 28.08.2026; A101 Revisjonsbokstav: A; A100 Fagkode: H-EL; A004 Område: Moflata; A003 Prosjektfase: Byggeplan; A002 Prosjektnummer: C15211; A001 Prosjektnavn: Rv. 36 Moflata; Novapoint UtilityNetwork - Volume: 0 m3
2 x _hjelpelinjer | A_Felles - A203 Objektstatus: Midlertidig; A202 MMI: 400; A200 Objektkode: 76356000; A201 Objektnavn: andre-kiosker-og-skap; A108 Godkjent av: OHTR; A0107 Kontrollert av: JHDA; A106 Utført av: NHMO; A105 Produsert for: Statens Vegvesen; A104 Produsert av: COWI; A103 Revisjonsmerknad: Arbeidsgrunnlag; A102 Revisjonsdato: 28.08.2026; A101 Revisjonsbokstav: A; A100 Fagkode: H-EL; A004 Område: Moflata; A003 Prosjektfase: Byggeplan; A002 Prosjektnummer: C15211; A001 Prosjektnavn: Rv. 36 Moflata
763502_fordelingfundament_EKS | A_Felles - A203 Objektstatus: Midlertidig; A202 MMI: 400; A200 Objektkode: 76356000; A201 Objektnavn: andre-kiosker-og-skap; A108 Godkjent av: OHTR; A0107 Kontrollert av: JHDA; A106 Utført av: NHMO; A105 Produsert for: Statens Vegvesen; A104 Produsert av: COWI; A103 Revisjonsmerknad: Arbeidsgrunnlag; A102 Revisjonsdato: 28.08.2026; A101 Revisjonsbokstav: A; A100 Fagkode: H-EL; A004 Område: Moflata; A003 Prosjektfase: Byggeplan; A002 Prosjektnummer: C15211; A001 Prosjektnavn: Rv. 36 Moflata; Novapoint UtilityNetwork - Volume: 0 m3
8 x _hjelpelinjer | A_Felles - A203 Objektstatus: Nytt; A202 MMI: 400; A200 Objektkode: 44460000; A201 Objektnavn: trekkekummer-prefabrikerte; A108 Godkjent av: OHTR; A0107 Kontrollert av: JHDA; A106 Utført av: COWI; A105 Produsert for: Statens Vegvesen; A104 Produsert av: COWI; A103 Revisjonsmerknad: Arbeidsgrunnlag; A102 Revisjonsdato: 28.08.2026; A101 Revisjonsbokstav: A; A100 Fagkode: I_Elektro; A004 Område: Moflata; A003 Prosjektfase: Byggeplan; A002 Prosjektnummer: C15211; A001 Prosjektnavn: Rv. 36 Moflata; I_Elektro - I007 Belastningsklasse: B125; I006 Material lokk: Støpejern; I005 Dimensjon: LxBxH: 1400x700x1200 mm; I003 Kumtype: TK2; I001 Eier av kum: VikenFiber, GlobalConnect, Telenor
2 x EL$EKS_Trekkekum | A_Felles - A203 Objektstatus: Nytt; A202 MMI: 400; A200 Objektkode: 44460000; A201 Objektnavn: trekkekummer-prefabrikerte; A108 Godkjent av: OHTR; A0107 Kontrollert av: JHDA; A106 Utført av: COWI; A105 Produsert for: Statens Vegvesen; A104 Produsert av: COWI; A103 Revisjonsmerknad: Arbeidsgrunnlag; A102 Revisjonsdato: 28.08.2026; A101 Revisjonsbokstav: A; A100 Fagkode: I_Elektro; A004 Område: Moflata; A003 Prosjektfase: Byggeplan; A002 Prosjektnummer: C15211; A001 Prosjektnavn: Rv. 36 Moflata; Novapoint UtilityNetwork - Volume: 0 m3; I_Elektro - I007 Belastningsklasse: B125; I006 Material lokk: Støpejern; I005 Dimensjon: LxBxH: 1400x700x1200 mm; I003 Kumtype: TK2; I001 Eier av kum: VikenFiber, GlobalConnect, Telenor
6 x 444610_trekkekumlokk_EKS | A_Felles - A203 Objektstatus: Nytt; A202 MMI: 400; A200 Objektkode: 44460000; A201 Objektnavn: trekkekummer-prefabrikerte; A108 Godkjent av: OHTR; A0107 Kontrollert av: JHDA; A106 Utført av: COWI; A105 Produsert for: Statens Vegvesen; A104 Produsert av: COWI; A103 Revisjonsmerknad: Arbeidsgrunnlag; A102 Revisjonsdato: 28.08.2026; A101 Revisjonsbokstav: A; A100 Fagkode: I_Elektro; A004 Område: Moflata; A003 Prosjektfase: Byggeplan; A002 Prosjektnummer: C15211; A001 Prosjektnavn: Rv. 36 Moflata; Novapoint UtilityNetwork - Volume: 0 m3; I_Elektro - I007 Belastningsklasse: B125; I006 Material lokk: Støpejern; I005 Dimensjon: LxBxH: 1400x700x1200 mm; I003 Kumtype: TK2; I001 Eier av kum: VikenFiber, GlobalConnect, Telenor
Føringsveier_elektro, Seksjon 231 - 232
Føringsveier_elektro, Seksjon 317 - 318
Føringsveier_elektro, Seksjon 316 - 317
Føringsveier_elektro, Seksjon 318 - 319
Føringsveier_elektro, Seksjon 319 - 320
Føringsveier_elektro, Seksjon 321 - 322
Føringsveier_elektro, Seksjon 320 - 321
Føringsveier_elektro, Seksjon 322 - 323
Føringsveier_elektro, Seksjon 226 - 227
Føringsveier_elektro, Seksjon 227 - 228
Føringsveier_elektro, Seksjon 230 - 231
Føringsveier_elektro, Seksjon 229 - 230
Føringsveier_elektro, Seksjon 228 - 229
Føringsveier_elektro, Seksjon 335 - 336
Føringsveier_elektro, Seksjon 338 - 339
Føringsveier_elektro, Seksjon 337 - 338
Føringsveier_elektro, Seksjon 336 - 337
Føringsveier_elektro, Seksjon 340 - 341
Føringsveier_elektro, Seksjon 339 - 340
Føringsveier_elektro, Seksjon 341 - 342
Føringsveier_elektro, Seksjon 342 - 343
Føringsveier_elektro, Seksjon 254 - 255
Føringsveier_elektro, Seksjon 255 - 256
Føringsveier_elektro, Seksjon 257 - 258
Føringsveier_elektro, Seksjon 256 - 257
Føringsveier_elektro, Seksjon 258 - 259
Føringsveier_elektro, Seksjon 262 - 263
Føringsveier_elektro, Seksjon 261 - 262
Føringsveier_elektro, Seksjon 259 - 260
Føringsveier_elektro, Seksjon 260 - 261

# IfcFlowSegment (95)
Novapoint UtilityNetwork - Volume: 0 m3
Name | Color | I100 Eier av føringsvei | I101 Type | I104 Dimensjon føringsvei | A001 Prosjektnavn | A002 Prosjektnummer | A003 Prosjektfase | A004 Område | A100 Fagkode | A101 Revisjonsbokstav | A102 Revisjonsdato | A103 Revisjonsmerknad | A104 Produsert av | A105 Produsert for | A106 Utført av | A0107 Kontrollert av | A108 Godkjent av | A202 MMI | A203 Objektstatus | A200 Objektkode | A201 Objektnavn
Føringsveier_elektro, Telenor_UtVarerørSør_NY, Trekkerør | 255,0,255 | Telenor | SN8 PP-rør | Ø110mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-110-mm | 44320000
Føringsveier_elektro, InnVarerørSør2, Trekkerør | 255,0,255 | Skien kommune | SN8 PP-rør | Ø110mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-110-mm | 44320000
2 x Føringsveier_elektro, InnVarerørSør2, Trekkerør 2 | 255,0,255 | Skien kommune | SN8 PP-rør | Ø110mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-110-mm | 44320000
2 x Føringsveier_elektro, InnVarerørSør2, Trekkerør 4 | 255,0,255 | Viken Fiber | SN64 DL-rør | Ø40mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-40-mm | 44310000
2 x Føringsveier_elektro, InnVarerørSør2, Trekkerør 5 | 255,0,255 | Viken Fiber | SN64 DL-rør | Ø40mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-40-mm | 44310000
2 x Føringsveier_elektro, InnVarerørSør2, Trekkerør 6 | 255,0,255 | Viken Fiber | SN64 DL-rør | Ø40mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-40-mm | 44310000
2 x Føringsveier_elektro, InnVarerørSør2, Trekkerør 7 | 255,0,255 | Global Connect | SN8 DL-rør | Ø40mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-40-mm | 44310000
2 x Føringsveier_elektro, InnVarerørSør2, Trekkerør 8 | 255,0,255 | Global Connect | SN8 DL-rør | Ø40mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-40-mm | 44310000
2 x Føringsveier_elektro, InnVarerørSør2, Trekkerør 9 | 255,0,255 | Global Connect | SN8 DL-rør | Ø40mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-40-mm | 44310000
Føringsveier_elektro, Telenor_Midlertidig_NY, Trekkerør | 255,0,255 | Telenor | SN8 PP-rør | Ø110mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-110-mm | 44320000
Føringsveier_elektro, Telenor_Midlertidig_NY, Trekkerør 2 | 255,0,255 | Telenor | SN8 PP-rør | Ø110mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-110-mm | 44320000
Føringsveier_elektro, ElviaNord, Høyspentkabel | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel; Length: 72.0081 m
Føringsveier_elektro, ElviaNord, Høyspentkabel 2 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 2; Length: 63.1898 m
Føringsveier_elektro, ElviaNord, Høyspentkabel 2 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 2; Length: 8.69906 m
Føringsveier_elektro, ElviaNord, Høyspentkabel 3 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 3; Length: 63.0734 m
Føringsveier_elektro, ElviaNord, Høyspentkabel 3 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 3; Length: 8.69631 m
Føringsveier_elektro, ElviaNord, Høyspentkabel 4 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 4; Length: 62.957 m
Føringsveier_elektro, ElviaNord, Høyspentkabel 4 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 4; Length: 8.69355 m
Føringsveier_elektro, ElviaNord, Høyspentkabel 5 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 5; Length: 62.8406 m
Føringsveier_elektro, ElviaNord, Høyspentkabel 5 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 5; Length: 8.69079 m
Føringsveier_elektro, ElviaNord, Høyspentkabel 6 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 6; Length: 62.7242 m
Føringsveier_elektro, ElviaNord, Høyspentkabel 6 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 6; Length: 8.68803 m
Føringsveier_elektro, ElviaNord, Jordleder | 255,0,255 | Lede | Cu-wire | 50mm2 | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | jordledning | 44280000 | Novapoint UtilityNetwork - PipeName: Jordleder; Length: 62.6255 m
Føringsveier_elektro, ElviaNord, Jordleder | 255,0,255 | Lede | Cu-wire | 50mm2 | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | jordledning | 44280000 | Novapoint UtilityNetwork - PipeName: Jordleder; Length: 8.68569 m
Føringsveier_elektro, ElviaNord2, Høyspentkabel | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel; Length: 9.53423 m
Føringsveier_elektro, ElviaNord2, Høyspentkabel 2 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 2; Length: 7.12576 m
Føringsveier_elektro, ElviaNord2, Høyspentkabel 2 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 2; Length: 2.53205 m
Føringsveier_elektro, ElviaNord2, Høyspentkabel 3 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 3; Length: 7.21404 m
Føringsveier_elektro, ElviaNord2, Høyspentkabel 3 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 3; Length: 2.5674 m
Føringsveier_elektro, ElviaNord2, Høyspentkabel 4 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 4; Length: 7.30234 m
Føringsveier_elektro, ElviaNord2, Høyspentkabel 4 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 4; Length: 2.60275 m
Føringsveier_elektro, ElviaNord2, Høyspentkabel 5 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 5; Length: 7.39067 m
Føringsveier_elektro, ElviaNord2, Høyspentkabel 5 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 5; Length: 2.6381 m
Føringsveier_elektro, ElviaNord2, Høyspentkabel 6 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 6; Length: 7.47903 m
Føringsveier_elektro, ElviaNord2, Høyspentkabel 6 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 6; Length: 2.67345 m
Føringsveier_elektro, ElviaNord2, Jordleder | 255,0,255 | Lede | Cu-wire | 50mm2 | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | jordledning | 44280000 | Novapoint UtilityNetwork - PipeName: Jordleder; Length: 7.55399 m
Føringsveier_elektro, ElviaNord2, Jordleder | 255,0,255 | Lede | Cu-wire | 50mm2 | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | jordledning | 44280000 | Novapoint UtilityNetwork - PipeName: Jordleder; Length: 2.70344 m
Føringsveier_elektro, ElviaSør, Høyspentkabel | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel; Length: 3.08542 m
Føringsveier_elektro, ElviaSør, Høyspentkabel 2 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 2; Length: 0.785997 m
Føringsveier_elektro, ElviaSør, Høyspentkabel 2 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 2; Length: 2.24087 m
Føringsveier_elektro, ElviaSør, Høyspentkabel 3 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 3; Length: 0.785997 m
Føringsveier_elektro, ElviaSør, Høyspentkabel 3 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 3; Length: 2.18232 m
Føringsveier_elektro, ElviaSør, Høyspentkabel 4 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 4; Length: 0.785997 m
Føringsveier_elektro, ElviaSør, Høyspentkabel 4 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 4; Length: 2.12379 m
Føringsveier_elektro, ElviaSør, Høyspentkabel 5 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 5; Length: 0.785997 m
Føringsveier_elektro, ElviaSør, Høyspentkabel 5 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 5; Length: 2.06528 m
Føringsveier_elektro, ElviaSør, Høyspentkabel 6 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 6; Length: 0.785997 m
Føringsveier_elektro, ElviaSør, Høyspentkabel 6 | 255,0,255 | Lede | Enfase-leder høyspent |  | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | høyspentkabler | 44210000 | Novapoint UtilityNetwork - PipeName: Høyspentkabel 6; Length: 2.00678 m
Føringsveier_elektro, ElviaSør, Jordleder | 255,0,255 | Lede | Cu-wire | 50mm2 | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | jordledning | 44280000 | Novapoint UtilityNetwork - PipeName: Jordleder; Length: 0.785997 m
Føringsveier_elektro, ElviaSør, Jordleder | 255,0,255 | Lede | Cu-wire | 50mm2 | Rv. 36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 300 | Nytt | jordledning | 44280000 | Novapoint UtilityNetwork - PipeName: Jordleder; Length: 1.95717 m
Føringsveier_elektro, InnVarerørSør, Trekkerør 2 | 255,0,255 | Skien kommune | SN8 PP-rør | Ø110mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-110-mm | 44320000
2 x Føringsveier_elektro, InnVarerørSør, Trekkerør 4 | 255,0,255 | Viken Fiber | SN64 DL-rør | Ø40mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-40-mm | 44310000
2 x Føringsveier_elektro, InnVarerørSør, Trekkerør 5 | 255,0,255 | Viken Fiber | SN64 DL-rør | Ø40mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-40-mm | 44310000
2 x Føringsveier_elektro, InnVarerørSør, Trekkerør 6 | 255,0,255 | Viken Fiber | SN64 DL-rør | Ø40mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-40-mm | 44310000
2 x Føringsveier_elektro, InnVarerørSør, Trekkerør 7 | 255,0,255 | Global Connect | SN8 DL-rør | Ø40mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-40-mm | 44310000
2 x Føringsveier_elektro, InnVarerørSør, Trekkerør 8 | 255,0,255 | Global Connect | SN8 DL-rør | Ø40mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-40-mm | 44310000
2 x Føringsveier_elektro, InnVarerørSør, Trekkerør 9 | 255,0,255 | Global Connect | SN8 DL-rør | Ø40mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-40-mm | 44310000
Føringsveier_elektro, InnVarerørSør, Trekkerør | 255,0,255
Føringsveier_elektro, InnVarerørSør, Trekkerør 2 | 255,0,255
Føringsveier_elektro, Telenor_Varerør-kum_Sør_NY, Trekkerør | 255,0,255 | Telenor | SN8 PP-rør | Ø110mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-110-mm | 44320000
Føringsveier_elektro, Varerør_EL, Varerør | 0,0,0 | Skien kommune, Telenor, Viken Fiber og Global Connect | Varerør | Ø500mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | 43490003 | Varerør-500-PE100 | Novapoint UtilityNetwork - Length: 24.6071 m; Name: Føringsveier_elektro, Varerør_EL, Varerør; PipeNetworkUsage: Surface Water; I_Elektro - I203 Dimensjon skap: Ø500mm
Føringsveier_elektro, StyrtborringElvia, Varerør | 0,0,0 | Lede | Varerør | Ø500mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | 43490003 | Varerør-500-PE100 | Novapoint UtilityNetwork - Length: 27.1925 m; Name: Føringsveier_elektro, StyrtborringElvia, Varerør; PipeNetworkUsage: Surface Water; I_Elektro - I203 Dimensjon skap: min. Ø500mm innvendig
2 x Føringsveier_elektro, UtVarerørNord, Trekkerør 9 | 255,0,255 | Global Connect | SN8 DL-rør | Ø40mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-40-mm | 44310000
Føringsveier_elektro, Telenor_midlertidig_sør-rv36, Trekkerør | 255,0,255 | Telenor | SN8 PP-rør | Ø110mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-110-mm | 44320000
Føringsveier_elektro, Telenor_Midlertidigtrekkerør_flettverksgjerde, Trekkerør | 255,0,255 | Telenor | SN8 DV-rør | Ø110mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt provisorisk | trekkerør-ø-110-mm | 44320000
Føringsveier_elektro, UtVarerørNord, Trekkerør | 255,0,255 | Skien kommune | SN8 PP-rør | Ø110mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-110-mm | 44320000
Føringsveier_elektro, UtVarerørNord, Trekkerør 2 | 255,0,255 | Skien kommune | SN8 PP-rør | Ø110mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-110-mm | 44320000
Føringsveier_elektro, UtVarerørNord, Trekkerør 2 | 255,0,255 |  |  |  | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-110-mm | 44320000
2 x Føringsveier_elektro, UtVarerørNord, Trekkerør 3 | 255,0,255 | Telenor | SN8 PP-rør | Ø110mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-110-mm | 44320000
2 x Føringsveier_elektro, UtVarerørNord, Trekkerør 4 | 255,0,255 | Viken Fiber | SN64 DL-rør | Ø40mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-40-mm | 44310000
2 x Føringsveier_elektro, UtVarerørNord, Trekkerør 5 | 255,0,255 | Viken Fiber | SN64 DL-rør | Ø40mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-40-mm | 44310000
2 x Føringsveier_elektro, UtVarerørNord, Trekkerør 6 | 255,0,255 | Viken Fiber | SN64 DL-rør | Ø40mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-40-mm | 44310000
2 x Føringsveier_elektro, UtVarerørNord, Trekkerør 7 | 255,0,255 | Global Connect | SN8 DL-rør | Ø40mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-40-mm | 44310000
2 x Føringsveier_elektro, UtVarerørNord, Trekkerør 8 | 255,0,255 | Global Connect | SN8 DL-rør | Ø40mm | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-40-mm | 44310000
Føringsveier_elektro, UtVarerørNord, Trekkerør | 255,0,255 |  |  |  | Rv.36 Moflata | C15211 | Byggeplan | Moflata | I_Elektro | A | 28.08.2026 | Arbeidsgrunnlag | COWI | Statens Vegvesen | NHMO | JHDA | OHTR | 400 | Nytt | trekkerør-ø-110-mm | 44320000
