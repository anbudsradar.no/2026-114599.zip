Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [Default Description]
File name: C:\Users\vblu\AppData\Local\Temp\1\Trimble\ConnectFolder\f-va.ifc
Time: 2026-05-20T08:27:23
Author: Vebjørn Bråthe Lund Vebjørn Bråthe Lund
Organization: Trimble Solutions Sandvika AS
Written by: Ifc Engine <1.0.1.1369>
Made in: Trimble Inc. - Novapoint - 27.0.1273.0
Authorization: Vebjørn Bråthe Lund Vebjørn Bråthe Lund

# IfcProject, Default Project
Description: Description of the Project

# IfcSite, Default Site
Description: Description of Site; RefLatitude: 9, 36, 7; RefLongitude: 59, 11, 13; RefElevation: 22.8023 m

# IfcBuilding, Default Building
Description: Description of Building; ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m
Pset_BuildingCommon - IsPermanentID: no; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2; NumberOfStoreys: 0; IsLandmarked: no
Pset_BuildingWaterStorage - WaterStorageRatePerPerson: 0 m3; OneDayPotableWater: 0 m3; OneDayEssentialWater: 0 m3; OneDayCoolingTowerMakeupWater: 0 m3; OneDayProcessOrProductionWater: 0 m3
ePset_BuildingEnergyTarget - BuildingEnergyTargetValue: 0

# IfcBuildingStorey
In: Default Building
Description: Land Development storey; Elevation: 0 m

# IfcDistributionFlowElement (15)
Novapoint UtilityNetwork - UtilityNetworkType: WS_StormwaterPipeNetwork; Diameter (DN): 1000
Common - Color: 0.0.0
H_VA - H004 Diameter: 1000
A_Felles - A100 Fagkode: H_VA; A001 Prosjektnavn: D121 Rv. 36 Moflata. byggeplan; A104 Produsert av: COWI; A105 Produsert for: Statens vegvesen; A106 Utført av: VBLU; A107 Kontrollert av: VUL; A202 MMI: 300; A203 Objektstatus: Nytt; A003 Prosjektfase: Byggeplan; A204 Materialtype: Betong; A102 Revisjonsdato: 25.03.2026; A005 Koordinatsystem: NTM sone 07 / NN2000
Name | Name | Navn = H001 Kumnummer | H005 Høyde på kum | H008 Lokktype | H002 Kumtype | A201 Objektnavn | A200 Objektkode
_f-dren, O1 | _f-dren. O1 | O1 | 1.88621 | SJK | OVK | overvannskum-1000-betong | 46310001
_f-dren, IFS3 | _f-dren. IFS3 | IFS3 | 2.68021 | Rist | SF | ifs-planrist-1000-betong | 46110002
_f-dren, IFS6 | _f-dren. IFS6 | IFS6 | 2.68016 | Kuppelrist | SF | ifs-kuppelrist-1000-betong | 46110001
_f-dren, IFS9 | _f-dren. IFS9 | IFS9 | 2.78017 | Rist | SF | ifs-planrist-1000-betong | 46110002
_f-dren, IFS7 | _f-dren. IFS7 | IFS7 | 2.67955 | Rist | SF | ifs-planrist-1000-betong | 46110002
_f-dren, IFS8 | _f-dren. IFS8 | IFS8 | 2.67991 | Rist | SF | ifs-planrist-1000-betong | 46110002
_f-dren, IFS10 | _f-dren. IFS10 | IFS10 | 2.4801 | Kuppelrist | SF | ifs-kuppelrist-1000-betong | 46110001
_f-dren, IFS11 | _f-dren. IFS11 | IFS11 | 2.68014 | Rist | SF | ifs-planrist-1000-betong | 46110002
_f-dren, IFS2 | _f-dren. IFS2 | IFS2 | 1.96927 | Kuppelrist | SF | ifs-kuppelrist-1000-betong | 46110001
_f-dren, IFS5 | _f-dren. IFS5 | IFS5 | 2.68037 | Rist | SF | ifs-planrist-1000-betong | 46110002
_f-dren, O2 | _f-dren. O2 | O2 | 2.49255 | SJK | OVK | overvannskum-1000-betong | 46310001
_f-dren, O4 | _f-dren. O4 | O4 | 2.30054 | SJK | OVK | overvannskum-1000-betong | 46310001
_f-dren, O3 | _f-dren. O3 | O3 | 2.54016 | SJK | OVK | overvannskum-1000-betong | 46310001
_f-dren, IFS4 | _f-dren. IFS4 | IFS4 | 2.68029 | Rist | SF | ifs-planrist-1000-betong | 46110002
_f-dren, IFS1 | _f-dren. IFS1 | IFS1 | 3.1103 | Kuppelrist | SF | ifs-kuppelrist-1000-betong | 46110001

# IfcFlowSegment (25)
Novapoint UtilityNetwork - Volume: 0 m3
A_Felles - A005 Koordinatsystem: NTM sone 07 / NN2000
Name | Name | Navn | PipeMaterial | UtilityNetworkType | PipeType | PipeWallThickness | PipeHorizontalLength | PipeDeltaZ | PipeNetworkUsage | Diameter (DN) | Color | H105 Styrkeklasse | H106 Fall | H103 Indre diameter | H104 Ytre diameter | H101 Fra kum | H003 Eier av anlegget = A105 Produsert for | H107 Lengde | A200 Objektkode | A201 Objektnavn | A100 Fagkode | A001 Prosjektnavn | A104 Produsert av | A106 Utført av | A107 Kontrollert av | A202 MMI | A203 Objektstatus | A003 Prosjektfase | A204 Materialtype | A108 Godkjent av
_f-dren, Trase1_OV315, 43240001-overvannsledning-315-PVC | _f-dren. Trase1_OV315. 43240001-overvannsledning-315-PVC | 43240001-overvannsledning-315-PVC | Polyvinylklorid uten mykner Trykkløs | WS_StormwaterPipeNetwork | StormwaterPipe | 9.2 | 28.2153 | -0.282369 | Surface Water | 315 | 0.0.0 | SN8 SDR 34 | -10.0 | 296.6 | 315 | O3 | Statens vegvesen | 28.22 | 43240001 | overvannsledning-315-PVC | H_VA | D121 Rv. 36 Moflata. byggeplan | COWI | VBLU | VUL | 300 | Nytt | Byggeplan | PVC | STHO | Novapoint UtilityNetwork - ToConnection: _f-dren. O4; H_VA - H102 Til kum: O4
_f-dren, Trase1_OV315, 43240001-overvannsledning-315-PVC | _f-dren. Trase1_OV315. 43240001-overvannsledning-315-PVC | 43240001-overvannsledning-315-PVC | Polyvinylklorid uten mykner Trykkløs | WS_StormwaterPipeNetwork | StormwaterPipe | 9.2 | 30.1436 | -4.43262 | Surface Water | 315 | 0.0.0 | SN8 SDR 34 | -147.0 | 296.6 | 315 | O4 | Statens vegvesen | 30.47 | 43240001 | overvannsledning-315-PVC | H_VA | D121 Rv. 36 Moflata. byggeplan | COWI | VBLU | VUL | 300 | Nytt | Byggeplan | PVC | STHO
_f-dren, IFS4, 43210001-overvannsledning-160-PVC | _f-dren. IFS4. 43210001-overvannsledning-160-PVC | 43210001-overvannsledning-160-PVC | Polyvinylklorid uten mykner Trykkløs | WS_StormwaterPipeNetwork | StormwaterPipe | 4.7 | 22.7654 | -0.258 | Surface Water | 160 | 0.0.0 | SN8 SDR 34 | -11.3 | 150.6 | 160 | IFS4 | Statens vegvesen | 22.77 | 43210001 | overvannsledning-160-PVC | H_VA | D121 Rv. 36 Moflata. byggeplan | COWI | VBLU | VUL | 300 | Nytt | Byggeplan | PVC | STHO | Novapoint UtilityNetwork - ToConnection: _f-dren. O1; H_VA - H102 Til kum: O1
_f-dren, IFS6, 43210001-overvannsledning-160-PVC | _f-dren. IFS6. 43210001-overvannsledning-160-PVC | 43210001-overvannsledning-160-PVC | Polyvinylklorid uten mykner Trykkløs | WS_StormwaterPipeNetwork | StormwaterPipe | 4.7 | 25.3835 | -0.759715 | Surface Water | 160 | 0.0.0 | SN8 SDR 34 | -29.9 | 150.6 | 160 | IFS6 | Statens vegvesen | 25.40 | 43210001 | overvannsledning-160-PVC | H_VA | D121 Rv. 36 Moflata. byggeplan | COWI | VBLU | VUL | 300 | Nytt | Byggeplan | PVC | STHO | Novapoint UtilityNetwork - ToConnection: _f-dren. O3; H_VA - H102 Til kum: O3
_f-dren, IFS5, 43210001-overvannsledning-160-PVC | _f-dren. IFS5. 43210001-overvannsledning-160-PVC | 43210001-overvannsledning-160-PVC | Polyvinylklorid uten mykner Trykkløs | WS_StormwaterPipeNetwork | StormwaterPipe | 4.7 | 8.93171 | -0.766 | Surface Water | 160 | 0.0.0 | SN8 SDR 34 | -85.8 | 150.6 | 160 | IFS5 | Statens vegvesen | 8.96 | 43210001 | overvannsledning-160-PVC | H_VA | D121 Rv. 36 Moflata. byggeplan | COWI | VBLU | VUL | 300 | Nytt | Byggeplan | PVC | STHO | Novapoint UtilityNetwork - ToConnection: _f-dren. O2; H_VA - H102 Til kum: O2
_f-dren, IFS9, 43210001-overvannsledning-160-PVC | _f-dren. IFS9. 43210001-overvannsledning-160-PVC | 43210001-overvannsledning-160-PVC | Polyvinylklorid uten mykner Trykkløs | WS_StormwaterPipeNetwork | StormwaterPipe | 4.7 | 6.98994 | -0.0652426 | Surface Water | 160 | 0.0.0 | SN8 SDR 34 | -9.3 | 150.6 | 160 | IFS9 | Statens vegvesen | 6.99 | 43210001 | overvannsledning-160-PVC | H_VA | D121 Rv. 36 Moflata. byggeplan | COWI | VBLU | VUL | 300 | Nytt | Byggeplan | PVC | STHO
_f-dren, Trase1_OV315, 43240001-overvannsledning-315-PVC | _f-dren. Trase1_OV315. 43240001-overvannsledning-315-PVC | 43240001-overvannsledning-315-PVC | Polyvinylklorid uten mykner Trykkløs | WS_StormwaterPipeNetwork | StormwaterPipe | 9.2 | 45.5218 | -0.454 | Surface Water | 315 | 0.0.0 | SN8 SDR 34 | -10.0 | 296.6 | 315 | O1 | Statens vegvesen | 45.52 | 43240001 | overvannsledning-315-PVC | H_VA | D121 Rv. 36 Moflata. byggeplan | COWI | VBLU | VUL | 300 | Nytt | Byggeplan | PVC | STHO | Novapoint UtilityNetwork - ToConnection: _f-dren. O2; H_VA - H102 Til kum: O2
_f-dren, Trase1_OV315, 43240001-overvannsledning-315-PVC | _f-dren. Trase1_OV315. 43240001-overvannsledning-315-PVC | 43240001-overvannsledning-315-PVC | Polyvinylklorid uten mykner Trykkløs | WS_StormwaterPipeNetwork | StormwaterPipe | 9.2 | 47.7019 | -0.477631 | Surface Water | 315 | 0.0.0 | SN8 SDR 34 | -10.0 | 296.6 | 315 | O2 | Statens vegvesen | 47.70 | 43240001 | overvannsledning-315-PVC | H_VA | D121 Rv. 36 Moflata. byggeplan | COWI | VBLU | VUL | 300 | Nytt | Byggeplan | PVC | STHO | Novapoint UtilityNetwork - ToConnection: _f-dren. O3; H_VA - H102 Til kum: O3
_f-dren, IFS3, 43210001-overvannsledning-160-PVC | _f-dren. IFS3. 43210001-overvannsledning-160-PVC | 43210001-overvannsledning-160-PVC | Polyvinylklorid uten mykner Trykkløs | WS_StormwaterPipeNetwork | StormwaterPipe | 4.7 | 5.10482 | -0.076 | Surface Water | 160 | 0.0.0 | SN8 SDR 34 | -14.9 | 150.6 | 160 | O1 | Statens vegvesen | 5.11 | 43210001 | overvannsledning-160-PVC | H_VA | D121 Rv. 36 Moflata. byggeplan | COWI | VBLU | VUL | 300 | Nytt | Byggeplan | PVC | STHO | Novapoint UtilityNetwork - ToConnection: _f-dren. IFS3; H_VA - H102 Til kum: IFS3
_f-dren, IFS1, 43210001-overvannsledning-160-PVC | _f-dren. IFS1. 43210001-overvannsledning-160-PVC | 43210001-overvannsledning-160-PVC | Polyvinylklorid uten mykner Trykkløs | WS_StormwaterPipeNetwork | StormwaterPipe | 4.7 | 5.42428 | -0.055398 | Surface Water | 160 | 0.0.0 | SN8 SDR 34 | -10.2 | 150.6 | 160 | IFS1 | Statens vegvesen | 5.42 | 43210001 | overvannsledning-160-PVC | H_VA | D121 Rv. 36 Moflata. byggeplan | COWI | VBLU | VUL | 300 | Nytt | Byggeplan | PVC | STHO
_f-dren, IFS7, 43210001-overvannsledning-160-PVC | _f-dren. IFS7. 43210001-overvannsledning-160-PVC | 43210001-overvannsledning-160-PVC | Polyvinylklorid uten mykner Trykkløs | WS_StormwaterPipeNetwork | StormwaterPipe | 4.7 | 11.6593 | -1.084 | Surface Water | 160 | 0.0.0 | SN8 SDR 34 | -93.0 | 150.6 | 160 | IFS7 | Statens vegvesen | 11.71 | 43210001 | overvannsledning-160-PVC | H_VA | D121 Rv. 36 Moflata. byggeplan | COWI | VBLU | VUL | 300 | Nytt | Byggeplan | PVC | STHO | Novapoint UtilityNetwork - ToConnection: _f-dren. O4; H_VA - H102 Til kum: O4
_f-dren, IFS8, 43210001-overvannsledning-160-PVC | _f-dren. IFS8. 43210001-overvannsledning-160-PVC | 43210001-overvannsledning-160-PVC | Polyvinylklorid uten mykner Trykkløs | WS_StormwaterPipeNetwork | StormwaterPipe | 4.7 | 3.89722 | -0.0388988 | Surface Water | 160 | 0.0.0 | SN8 SDR 34 | -10.0 | 150.6 | 160 | IFS8 | Statens vegvesen | 3.90 | 43210001 | overvannsledning-160-PVC | H_VA | D121 Rv. 36 Moflata. byggeplan | COWI | VBLU | VUL | 300 | Nytt | Byggeplan | PVC | STHO
_f-dren, IFS10, 43210001-overvannsledning-160-PVC | _f-dren. IFS10. 43210001-overvannsledning-160-PVC | 43210001-overvannsledning-160-PVC | Polyvinylklorid uten mykner Trykkløs | WS_StormwaterPipeNetwork | StormwaterPipe | 4.7 | 1.8467 | -0.04 | Surface Water | 160 | 0.0.0 | SN8 SDR 34 | -21.7 | 150.6 | 160 | IFS10 | Statens vegvesen | 1.85 | 43210001 | overvannsledning-160-PVC | H_VA | D121 Rv. 36 Moflata. byggeplan | COWI | VBLU | VUL | 300 | Nytt | Byggeplan | PVC | STHO | Novapoint UtilityNetwork - ToConnection: _f-dren. IFS9; H_VA - H102 Til kum: IFS9
_f-dren, IFS11, 43210001-overvannsledning-160-PVC | _f-dren. IFS11. 43210001-overvannsledning-160-PVC | 43210001-overvannsledning-160-PVC | Polyvinylklorid uten mykner Trykkløs | WS_StormwaterPipeNetwork | StormwaterPipe | 4.7 | 2.56157 | 0.009467 | Surface Water | 160 | 0.0.0 | SN8 SDR 34 | 3.7 | 150.6 | 160 | IFS11 | Statens vegvesen | 2.56 | 43210001 | overvannsledning-160-PVC | H_VA | D121 Rv. 36 Moflata. byggeplan | COWI | VBLU | VUL | 300 | Nytt | Byggeplan | PVC | STHO
_f-dren, IFS2, 43210001-overvannsledning-160-PVC | _f-dren. IFS2. 43210001-overvannsledning-160-PVC | 43210001-overvannsledning-160-PVC | Polyvinylklorid uten mykner Trykkløs | WS_StormwaterPipeNetwork | StormwaterPipe | 4.7 | 11.1405 | -0.113683 | Surface Water | 160 | 0.0.0 | SN8 SDR 34 | -10.2 | 150.6 | 160 | IFS2 | Statens vegvesen | 11.14 | 43210001 | overvannsledning-160-PVC | H_VA | D121 Rv. 36 Moflata. byggeplan | COWI | VBLU | VUL | 300 | Nytt | Byggeplan | PVC | STHO
_f-dren, SP280, 43330001-spillvannsledning-280-PVC |  | 43330001-spillvannsledning-280-PVC | Polyvinylklorid uten mykner Trykkledning | WS_SewerNetwork | SewerPipe | 8.6 | 8.96033 | -0.130183 |  | 280 | 0.255.0 | PN6 SDR 33 | -14.5 | 262.8 | 280 |  |  | 8.96 | Novapoint UtilityNetwork - PipeName: 43330001-spillvannsledning-280-PVC; Bruk: Waste Water
_f-dren, OV200, 43220001-overvannsledning-200-PVC | _f-dren. OV200. 43220001-overvannsledning-200-PVC | 43220001-overvannsledning-200-PVC | Polyvinylklorid uten mykner Trykkløs | WS_StormwaterPipeNetwork | StormwaterPipe | 5.9 | 86.8608 | -1.34528 | Surface Water | 200 | 0.0.0 | SN8 SDR 34 | -15.5 | 188.2 | 200 |  |  | 86.87
_f-dren, SP280, 43330001-spillvannsledning-280-PVC |  | 43330001-spillvannsledning-280-PVC | Polyvinylklorid uten mykner Trykkledning | WS_SewerNetwork | SewerPipe | 8.6 | 20.5716 | -0.298881 |  | 280 | 0.255.0 | PN6 SDR 33 | -14.5 | 262.8 | 280 |  |  | 20.57 | Novapoint UtilityNetwork - PipeName: 43330001-spillvannsledning-280-PVC; Bruk: Waste Water
_f-dren, VL150, 43420001-vannledning-150-SJK |  | 43420001-vannledning-150-SJK | Polyetylen 100 | WS_WaterPipeNetwork | WaterPipe | 4 | 58.447 | -0.826598 |  | 150 | 0.0.255 | C64 | -14.1 | 142 | 150 |  |  | 58.45
_f-dren, VL150, 43490001-varerør-315-PE100 |  | 43490001-varerør-315-PE100 | Polyetylen 100 | WS_WaterPipeNetwork | WaterPipe | 28.6 | 58.447 | -0.80272 |  | 315 | 0.0.255 | PN12.5 SDR 11 | -13.7 | 257.8 | 315 |  |  | 58.45
_f-dren, VL150, 43420001-vannledning-150-SJK |  | 43420001-vannledning-150-SJK | Duktilt støpejern | WS_WaterPipeNetwork | WaterPipe | 4 | 9.97912 | -0.141131 |  | 150 | 0.0.255 | C64 | -14.1 | 150 | 158 |  |  | 9.98
_f-dren, VL150, 43420001-vannledning-150-SJK |  | 43420001-vannledning-150-SJK | Duktilt støpejern | WS_WaterPipeNetwork | WaterPipe | 4 | 21.3715 | -0.302251 |  | 150 | 0.0.255 | C64 | -14.1 | 150 | 158 |  |  | 21.37
_f-dren, OV200, 43490002-varerør-400-PE100 | _f-dren. OV200. 43490002-varerør-400-PE100 | 43490002-varerør-400-PE100 | Polyetylen 100 | WS_StormwaterPipeNetwork | StormwaterPipe | 36.3 | 58.4101 | -0.934331 | Surface Water | 400 | 0.0.0 | PN12.5 SDR 11 | -16.0 | 327.4 | 400
_f-dren, SP280, 43330001-spillvannsledning-280-PVC |  | 43330001-spillvannsledning-280-PVC | Polyvinylklorid uten mykner Trykkløs | WS_SewerNetwork | SewerPipe | 8.3 | 58.4027 | -0.848522 |  | 280 | 0.255.0 | SN8 SDR 34 | -14.5 | 263.4 | 280 |  |  | 58.41 | Novapoint UtilityNetwork - PipeName: 43330001-spillvannsledning-280-PVC; Bruk: Waste Water
_f-dren, SP280, 43490003-varerør-500-PE100 |  | 43490003-varerør-500-PE100 | Polyetylen 100 | WS_SewerNetwork | SewerPipe | 45.4 | 58.4027 | -0.846148 |  | 500 | 0.255.0 | PN12.5 SDR 11 | -14.5 | 409.2 | 500 | Novapoint UtilityNetwork - PipeName: 43490003-varerør-500-PE100; Bruk: Waste Water

# IfcFlowTerminal (90)
H_VA - H004 Diameter: 1000
Novapoint UtilityNetwork - UtilityNetworkType: WS_StormwaterPipeNetwork
A_Felles - A100 Fagkode: H_VA; A001 Prosjektnavn: D121 Rv. 36 Moflata. byggeplan; A104 Produsert av: COWI; A105 Produsert for: Statens vegvesen; A106 Utført av: VBLU; A107 Kontrollert av: VUL; A202 MMI: 300; A203 Objektstatus: Nytt; A003 Prosjektfase: Byggeplan; A102 Revisjonsdato: 25.03.2026; A005 Koordinatsystem: NTM sone 07 / NN2000
Name | H001 Kumnummer | H002 Kumtype | H005 Høyde på kum | H007 Diameter lokk | H008 Lokktype | Navn | Volume (m3) | A201 Objektnavn | A200 Objektkode | A204 Materialtype | Color
_f-dren, O1, Lokk | O1 | OVK | 1.88621 | 650 | SJK | O1 | 0.0149451 | overvannskum-1000-betong | 46310001 | SJK
_f-dren, IFS3, Lokk | IFS3 | SF | 2.68021 | 650 | Rist | IFS3 | 0.00498168 | ifs-planrist-1000-betong | 46110002 | SJK
_f-dren, O1, Justeringsring | O1 | OVK | 1.88621 | 650 | SJK | O1 | 0.0192643 | overvannskum-1000-betong | 46310001 | Betong | 0.0.0
_f-dren, IFS3, Justeringsring | IFS3 | SF | 2.68021 | 650 | Rist | IFS3 | 0.0192643 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, O1, Bunnring | O1 | OVK | 1.88621 | 650 | SJK | O1 | 0.364973 | overvannskum-1000-betong | 46310001 | Betong | 0.0.0
_f-dren, IFS3, Bunnring | IFS3 | SF | 2.68021 | 650 | Rist | IFS3 | 0.590278 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, O1, Bunnplate | O1 | OVK | 1.88621 | 650 | SJK | O1 | 0.100689 | overvannskum-1000-betong | 46310001 | Betong | 0.0.0
_f-dren, IFS3, Bunnplate | IFS3 | SF | 2.68021 | 650 | Rist | IFS3 | 0.100689 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, O1, Bunnseksjon |  | OVK |  |  |  | O1 |  | overvannskum-1000-betong | 46310001 | Betong | 0.0.0
_f-dren, IFS3, Bunnseksjon |  | SF |  |  |  | IFS3 |  | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS3, Kjegle | IFS3 | SF | 2.68021 | 650 | Rist | IFS3 | 0.141879 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, O1, Kjegle | O1 | OVK | 1.88621 | 650 | SJK | O1 | 0.141879 | overvannskum-1000-betong | 46310001 | Betong | 0.0.0
_f-dren, IFS9, Justeringsring | IFS9 | SF | 2.78017 | 650 | Rist | IFS9 | 0.0192643 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS9, Lokk | IFS9 | SF | 2.78017 | 650 | Rist | IFS9 | 0.00498168 | ifs-planrist-1000-betong | 46110002 | SJK
_f-dren, IFS9, Bunnring | IFS9 | SF | 2.78017 | 650 | Rist | IFS9 | 0.618642 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS9, Bunnplate | IFS9 | SF | 2.78017 | 650 | Rist | IFS9 | 0.100689 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS9, Bunnseksjon |  | SF |  |  |  | IFS9 |  | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS9, Kjegle | IFS9 | SF | 2.78017 | 650 | Rist | IFS9 | 0.141879 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS6, Justeringsring | IFS6 | SF | 2.68016 | 650 | Kuppelrist | IFS6 | 0.0192643 | ifs-kuppelrist-1000-betong | 46110001 | Betong | 0.0.0
_f-dren, IFS1, Lokk | IFS1 | SF | 3.1103 | 650 | Kuppelrist | IFS1 | 0.0777143 | ifs-kuppelrist-1000-betong | 46110001 | SJK
_f-dren, IFS1, Bunnring | IFS1 | SF | 3.1103 | 650 | Kuppelrist | IFS1 | 0.712319 | ifs-kuppelrist-1000-betong | 46110001 | Betong | 0.0.0
_f-dren, IFS1, Bunnplate | IFS1 | SF | 3.1103 | 650 | Kuppelrist | IFS1 | 0.100689 | ifs-kuppelrist-1000-betong | 46110001 | Betong | 0.0.0
_f-dren, IFS7, Lokk | IFS7 | SF | 2.67955 | 650 | Rist | IFS7 | 0.00498168 | ifs-planrist-1000-betong | 46110002 | SJK
_f-dren, IFS7, Justeringsring | IFS7 | SF | 2.67955 | 650 | Rist | IFS7 | 0.0192643 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS7, Bunnring | IFS7 | SF | 2.67955 | 650 | Rist | IFS7 | 0.590089 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS7, Bunnplate | IFS7 | SF | 2.67955 | 650 | Rist | IFS7 | 0.100689 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS7, Bunnseksjon |  | SF |  |  |  | IFS7 |  | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS7, Kjegle | IFS7 | SF | 2.67955 | 650 | Rist | IFS7 | 0.141879 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS10, Lokk | IFS10 | SF | 2.4801 | 650 | Kuppelrist | IFS10 | 0.0777143 | ifs-kuppelrist-1000-betong | 46110001 | SJK
_f-dren, IFS8, Lokk | IFS8 | SF | 2.67991 | 650 | Rist | IFS8 | 0.00498168 | ifs-planrist-1000-betong | 46110002 | SJK
_f-dren, IFS8, Justeringsring | IFS8 | SF | 2.67991 | 650 | Rist | IFS8 | 0.0192643 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS8, Bunnring | IFS8 | SF | 2.67991 | 650 | Rist | IFS8 | 0.590192 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS10, Justeringsring | IFS10 | SF | 2.4801 | 650 | Kuppelrist | IFS10 | 0.0192643 | ifs-kuppelrist-1000-betong | 46110001 | Betong | 0.0.0
_f-dren, IFS10, Bunnring | IFS10 | SF | 2.4801 | 650 | Kuppelrist | IFS10 | 0.533495 | ifs-kuppelrist-1000-betong | 46110001 | Betong | 0.0.0
_f-dren, IFS8, Bunnplate | IFS8 | SF | 2.67991 | 650 | Rist | IFS8 | 0.100689 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS10, Bunnplate | IFS10 | SF | 2.4801 | 650 | Kuppelrist | IFS10 | 0.100689 | ifs-kuppelrist-1000-betong | 46110001 | Betong | 0.0.0
_f-dren, IFS8, Bunnseksjon |  | SF |  |  |  | IFS8 |  | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS10, Bunnseksjon |  | SF |  |  |  | IFS10 |  | ifs-kuppelrist-1000-betong | 46110001 | Betong | 0.0.0
_f-dren, IFS8, Kjegle | IFS8 | SF | 2.67991 | 650 | Rist | IFS8 | 0.141879 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS10, Kjegle | IFS10 | SF | 2.4801 | 650 | Kuppelrist | IFS10 | 0.141879 | ifs-kuppelrist-1000-betong | 46110001 | Betong | 0.0.0
_f-dren, IFS11, Bunnseksjon |  | SF |  |  |  | IFS11 |  | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS11, Bunnplate | IFS11 | SF | 2.68014 | 650 | Rist | IFS11 | 0.100689 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS11, Bunnring | IFS11 | SF | 2.68014 | 650 | Rist | IFS11 | 0.590258 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS11, Kjegle | IFS11 | SF | 2.68014 | 650 | Rist | IFS11 | 0.141879 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS11, Lokk | IFS11 | SF | 2.68014 | 650 | Rist | IFS11 | 0.00498168 | ifs-planrist-1000-betong | 46110002 | SJK
_f-dren, IFS11, Justeringsring | IFS11 | SF | 2.68014 | 650 | Rist | IFS11 | 0.0192643 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS2, Lokk | IFS2 | SF | 1.96927 | 650 | Kuppelrist | IFS2 | 0.0777143 | ifs-kuppelrist-1000-betong | 46110001 | SJK
_f-dren, IFS2, Bunnring | IFS2 | SF | 1.96927 | 650 | Kuppelrist | IFS2 | 0.388543 | ifs-kuppelrist-1000-betong | 46110001 | Betong | 0.0.0
_f-dren, IFS2, Bunnplate | IFS2 | SF | 1.96927 | 650 | Kuppelrist | IFS2 | 0.100689 | ifs-kuppelrist-1000-betong | 46110001 | Betong | 0.0.0
_f-dren, IFS2, Bunnseksjon |  | SF |  |  |  | IFS2 |  | ifs-kuppelrist-1000-betong | 46110001 | Betong | 0.0.0
_f-dren, IFS2, Kjegle | IFS2 | SF | 1.96927 | 650 | Kuppelrist | IFS2 | 0.141879 | ifs-kuppelrist-1000-betong | 46110001 | Betong | 0.0.0
_f-dren, IFS2, Justeringsring | IFS2 | SF | 1.96927 | 650 | Kuppelrist | IFS2 | 0.0192643 | ifs-kuppelrist-1000-betong | 46110001 | Betong | 0.0.0
_f-dren, IFS6, Lokk | IFS6 | SF | 2.68016 | 650 | Kuppelrist | IFS6 | 0.0777143 | ifs-kuppelrist-1000-betong | 46110001 | SJK
_f-dren, IFS5, Lokk | IFS5 | SF | 2.68037 | 650 | Rist | IFS5 | 0.00498168 | ifs-planrist-1000-betong | 46110002 | SJK
_f-dren, IFS5, Justeringsring | IFS5 | SF | 2.68037 | 650 | Rist | IFS5 | 0.0192643 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS5, Bunnring | IFS5 | SF | 2.68037 | 650 | Rist | IFS5 | 0.590322 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS6, Bunnring | IFS6 | SF | 2.68016 | 650 | Kuppelrist | IFS6 | 0.590264 | ifs-kuppelrist-1000-betong | 46110001 | Betong | 0.0.0
_f-dren, IFS5, Bunnplate | IFS5 | SF | 2.68037 | 650 | Rist | IFS5 | 0.100689 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS6, Bunnplate | IFS6 | SF | 2.68016 | 650 | Kuppelrist | IFS6 | 0.100689 | ifs-kuppelrist-1000-betong | 46110001 | Betong | 0.0.0
_f-dren, IFS5, Bunnseksjon |  | SF |  |  |  | IFS5 |  | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS6, Bunnseksjon |  | SF |  |  |  | IFS6 |  | ifs-kuppelrist-1000-betong | 46110001 | Betong | 0.0.0
_f-dren, IFS5, Kjegle | IFS5 | SF | 2.68037 | 650 | Rist | IFS5 | 0.141879 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS6, Kjegle | IFS6 | SF | 2.68016 | 650 | Kuppelrist | IFS6 | 0.141879 | ifs-kuppelrist-1000-betong | 46110001 | Betong | 0.0.0
_f-dren, O2, Lokk | O2 | OVK | 2.49255 | 650 | SJK | O2 | 0.0149451 | overvannskum-1000-betong | 46310001 | SJK
_f-dren, O4, Lokk | O4 | OVK | 2.30054 | 650 | SJK | O4 | 0.0149451 | overvannskum-1000-betong | 46310001 | SJK
_f-dren, O3, Lokk | O3 | OVK | 2.54016 | 650 | SJK | O3 | 0.0149451 | overvannskum-1000-betong | 46310001 | SJK
_f-dren, IFS4, Lokk | IFS4 | SF | 2.68029 | 650 | Rist | IFS4 | 0.00498168 | ifs-planrist-1000-betong | 46110002 | SJK
_f-dren, O4, Justeringsring | O4 | OVK | 2.30054 | 650 | SJK | O4 | 0.0192643 | overvannskum-1000-betong | 46310001 | Betong | 0.0.0
_f-dren, O2, Justeringsring | O2 | OVK | 2.49255 | 650 | SJK | O2 | 0.0192643 | overvannskum-1000-betong | 46310001 | Betong | 0.0.0
_f-dren, O3, Justeringsring | O3 | OVK | 2.54016 | 650 | SJK | O3 | 0.0192643 | overvannskum-1000-betong | 46310001 | Betong | 0.0.0
_f-dren, IFS4, Justeringsring | IFS4 | SF | 2.68029 | 650 | Rist | IFS4 | 0.0192643 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, O4, Bunnring | O4 | OVK | 2.30054 | 650 | SJK | O4 | 0.482543 | overvannskum-1000-betong | 46310001 | Betong | 0.0.0
_f-dren, O2, Bunnring | O2 | OVK | 2.49255 | 650 | SJK | O2 | 0.537027 | overvannskum-1000-betong | 46310001 | Betong | 0.0.0
_f-dren, O3, Bunnring | O3 | OVK | 2.54016 | 650 | SJK | O3 | 0.550537 | overvannskum-1000-betong | 46310001 | Betong | 0.0.0
_f-dren, IFS4, Bunnring | IFS4 | SF | 2.68029 | 650 | Rist | IFS4 | 0.5903 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, O2, Bunnplate | O2 | OVK | 2.49255 | 650 | SJK | O2 | 0.100689 | overvannskum-1000-betong | 46310001 | Betong | 0.0.0
_f-dren, O4, Bunnplate | O4 | OVK | 2.30054 | 650 | SJK | O4 | 0.100689 | overvannskum-1000-betong | 46310001 | Betong | 0.0.0
_f-dren, O3, Bunnplate | O3 | OVK | 2.54016 | 650 | SJK | O3 | 0.100689 | overvannskum-1000-betong | 46310001 | Betong | 0.0.0
_f-dren, IFS4, Bunnplate | IFS4 | SF | 2.68029 | 650 | Rist | IFS4 | 0.100689 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, O2, Bunnseksjon |  | OVK |  |  |  | O2 |  | overvannskum-1000-betong | 46310001 | Betong | 0.0.0
_f-dren, O4, Bunnseksjon |  | OVK |  |  |  | O4 |  | overvannskum-1000-betong | 46310001 | Betong | 0.0.0
_f-dren, O3, Bunnseksjon |  | OVK |  |  |  | O3 |  | overvannskum-1000-betong | 46310001 | Betong | 0.0.0
_f-dren, IFS4, Bunnseksjon |  | SF |  |  |  | IFS4 |  | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, O4, Kjegle | O4 | OVK | 2.30054 | 650 | SJK | O4 | 0.141879 | overvannskum-1000-betong | 46310001 | Betong | 0.0.0
_f-dren, O2, Kjegle | O2 | OVK | 2.49255 | 650 | SJK | O2 | 0.141879 | overvannskum-1000-betong | 46310001 | Betong | 0.0.0
_f-dren, O3, Kjegle | O3 | OVK | 2.54016 | 650 | SJK | O3 | 0.141879 | overvannskum-1000-betong | 46310001 | Betong | 0.0.0
_f-dren, IFS4, Kjegle | IFS4 | SF | 2.68029 | 650 | Rist | IFS4 | 0.141879 | ifs-planrist-1000-betong | 46110002 | Betong | 0.0.0
_f-dren, IFS1, Bunnseksjon |  | SF |  |  |  | IFS1 |  | ifs-kuppelrist-1000-betong | 46110001 | Betong | 0.0.0
_f-dren, IFS1, Kjegle | IFS1 | SF | 3.1103 | 650 | Kuppelrist | IFS1 | 0.141879 | ifs-kuppelrist-1000-betong | 46110001 | Betong | 0.0.0
_f-dren, IFS1, Justeringsring | IFS1 | SF | 3.1103 | 650 | Kuppelrist | IFS1 | 0.0192643 | ifs-kuppelrist-1000-betong | 46110001 | Betong | 0.0.0
